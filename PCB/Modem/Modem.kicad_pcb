# Repository ahmadexp/Open-Source-PC110 (continued)

## KiCad design Mods/PC110-ITX-all-in-one/PC110.kicad_pcb (continued)

Schematic: PSU.kicad_sch, PC110 Power Supply Unit

Parts:
C362, C365: 1.5uF; C_1206_3216Metric
C363: 2.5nF; C_0603_1608Metric
C364: 3.6nF; C_0603_1608Metric
C366, C369, C372, C376, C402, C409, C412, C423, C425, C426: 10nF; C_0603_1608Metric
C367, C404: 100nF; C_0603_1608Metric
C368, C374, C398, C401, C407: 180nF; C_0603_1608Metric
C370: 18uF 50V; C_Radial_D6.3mm_H11.0mm_P2.50mm
C371: 15uF 16V; C_Radial_D6.3mm_H11.0mm_P2.50mm
C373, C387, C389, C397, C399: 1.2nF; C_0603_1608Metric
C375: 5.1nF; C_0603_1608Metric
C377, C391: 100pF; C_0603_1608Metric
C378, C394: 24nF; C_0603_1608Metric
C379: 4.7nF; C_0603_1608Metric
C380, C381, C385, C386, C390, C406, C413, C416, C420, C422: 150nF; C_0603_1608Metric
C382, C383, C395, C418, C419, C421: 1.5uF; C_0805_2012Metric
C384, C392, C393, C417, C424: 120nF; C_0603_1608Metric
C388, C410: 1nF; C_0603_1608Metric
C396: 10pF; C_0603_1608Metric
C400, C427: 47uF 6.3v; C_Radial_D6.3mm_H11.0mm_P2.50mm
C403: 33uF 20V; C_Disc_D3.0mm_W1.6mm_P2.50mm
C405: 56uF 25V EC; EC
C408: 5.2uF; C_1206_3216Metric
C411: 1.2uF; C_1206_3216Metric
C414: 18nF; C_0603_1608Metric
C415: 12nF; C_0603_1608Metric
C428: 47uF 6.3V; C_Radial_D6.3mm_H11.0mm_P2.50mm
D63: 8-2; D_0603_1608Metric
D64, D67: DNP; D_1206_3216Metric; not fitted
D65: 3^9; D_0603_1608Metric
D66: 5-9; D_0603_1608Metric
D68, D69: s.3 4F; D_1206_3216Metric
D70: 18; D_0603_1608Metric
F6: 10; Fuse_1210_3225Metric
F7: 15; Fuse_1206_3216Metric
F8, F10: 2.5A; Fuse_2010_5025Metric
F9: 830mA; Fuse_2010_5025Metric
J19: Backllight_Connector
J20: PSU_Jack
JX1: Main Battery; TerminalBlock_Phoenix_PTSM-0,5-4-HV-2.5-SMD_1x04-1MP_P2.50m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
L77: 470uH; L_Coilcraft_LPS5030
L78: 68uH; L_Coilcraft_LPS5030
L79, L81: 10uH; L_Radial_D10.0mm_P5.00mm_Fastron_07M
L80: 10uH; L_Radial_D7.5mm_P5.00mm_Fastron_07P
Q47: 303 5H; SOT-powerT
Q48: 103 5G; SOT-powerT
Q49, Q50, Q53, Q56, Q59, Q62, Q82: 8C; SOT-416
Q51, Q52, Q55, Q67, Q68, Q74, Q81: 6LS; SOT-416
Q54, Q58, Q64, Q75, Q76: 8LR; SOT-416
Q57, Q77: K; 3D
Q60, Q69, Q78: M2P; 3D
Q61, Q71, Q73: W6; 3D
Q63: 8LB; SOT-416
Q65: G16; SOT-23-PC110
Q66: H15; SOT-23-PC110
Q70, Q83: Q; 3D
Q72: KD 3.E; SOT-89-3
Q79: R4C; 3D
Q80: 3P4J; TO-252-2
R498, R499, R508, R521, R522, R524, R525, R526, R527, R540, R541, R542, R545, R557, R561, R564, R590, R600, R624: 10k; R_0603_1608Metric
R500, R509, R518, R535, R547, R623, R639: 47k; R_0603_1608Metric
R501: 2.2k; R_0603_1608Metric
R502, R511, R512, R513, R538, R560, R625, R635: 1k; R_0603_1608Metric
R503: 220; R_0603_1608Metric
R504, R630: 470; R_0603_1608Metric
R505: 120; R_0603_1608Metric
R506, R519, R520, R533, R548, R549, R552, R588, R592, R627, R642: 100k; R_0603_1608Metric
R507, R544, R559, R563, R599, R619: 200k; R_0603_1608Metric
R510: 11K; R_0603_1608Metric
R514, R517, R555, R558, R562, R566, R587, R629, R634: 470k; R_0603_1608Metric
R515: 130k; R_0603_1608Metric
R516: 15k; R_0603_1608Metric
R523, R591: DNP; R_0603_1608Metric; not fitted
R528: 12k; R_0603_1608Metric
R529, R536, R546, R633: 20k; R_0603_1608Metric
R530, R531, R534, R539, R596, R598, R631: 4.7k; R_0603_1608Metric
R532, R628, R637: 100; R_0603_1608Metric
R537, R620, R621: DNP; R_0603_1608Metric
R543, R565, R593, R594: 1M; R_0603_1608Metric
R550, R553: 0.1; R_1210_3225Metric
R551: 33; R_0603_1608Metric
R554, R556, R586, R589: 300k; R_0603_1608Metric
R567, R568, R569, R570, R571, R572, R573, R574, R575, R576, R577, R578, R579, R580, R581, R602, R603, R604, R605, R606, R607, R608, R609, R610, R611, R612, R613, R614, R615, R616, R617, R632: 0; R_0603_1608Metric
R582, R643, R644, R645: 0.1; R_1206_3216Metric
R583: 0.22; R_1206_3216Metric
R584: DNP; R_1206_3216Metric
R585, R601: 300; R_0603_1608Metric
R595: 103 (RT2); R_1206_3216Metric
R597: 103 (RT1); R_1206_3216Metric
R618, R622: 7.5k; R_0603_1608Metric
R626: 2k; R_0603_1608Metric
R636: 1.8k; R_0603_1608Metric
R638, R646: DNP; R_1206_3216Metric; not fitted
R640, R641: 0; R_1206_3216Metric
SW3: PSU-SW1
U81: 7W14; SSOP-8-PSU
U82: 9742; SSOP-16_4.4x5.2mm_P0.65mm
U83: 6.5 5F; SOT-23-6_Handsoldering
U84: TA; SOT-23-5
U85: 5W01; SSOP-8-PSU
U86: 7064; TSSOP-14_4.4x5mm_P0.65mm
U87, U88: J421; SOP-8_3.9x4.9mm_P1.27mm
U89: K2337; SOP-8_3.9x4.9mm_P1.27mm
U90: MAX786CAI; TSSOP-28_6.1x9.7mm_P0.65mm
U91: D9D; SOT-23-5
U92, U93: 2556; SOP-8_3.9x4.9mm_P1.27mm

Connections:
/PSU/D2_3_PC110: Q50.3 (C), R606.2 (-)
/PSU/D18_2_3_PC110: J19.1, R617.2 (-)
/PSU/D28_1_PC110: C371.1 (+), C374.1 (+), C377.2 (-), Q48.4, R515.2 (-), R573.2 (-)
/PSU/F65_ENAVEE_PC110: R519.1 (+), R613.2 (-)
/PSU/J5_6_PC110: D63.1 (K), Q57.1 (A), R570.2 (-)
/PSU/J5_33_PC110: C366.1 (+), R502.2 (-), R506.1 (+), R611.2 (-)
/PSU/M38_P20_PC110: Q73.1 (A), Q75.1 (B), R580.2 (-)
/PSU/M38_P21_PC110: Q73.3 (A), R616.2 (-)
/PSU/M38_P52_PC110: R517.1 (+), R579.2 (-)
/PSU/M38_P53_PC110: Q61.1 (A), R615.2 (-)
/PSU/M38_P60_PC110: C399.1 (+), R563.1 (+), R567.2 (-), U86.8
/PSU/M38_P61_PC110: C410.1 (+), R568.2 (-), R619.1 (+), R623.1 (+), U86.14
/PSU/M38_P63_PC110: C391.1 (+), R547.2 (-), R549.1 (+), R602.2 (-), U86.1
/PSU/M38_P64_PC110: R591.1 (+), R592.1 (+), R607.2 (-), U86.7
/PSU/M38_VREF_PC110: C420.2 (-), Q79.3 (K), Q81.2 (E), R609.2 (-), R630.1 (+)
/PSU/PNET1_PC110: R571.2 (-), R608.2 (-)
/PSU/Q43_2_PC110: C369.2 (-), C370.2 (-), C372.2 (-), Q47.4, R507.2 (-), R574.2 (-)
/PSU/Q49_1_PC110: D65.2 (A), R603.2 (-), R621.2 (-)
/PSU/R73_2_PC110: R509.2 (-), R576.2 (-)
/PSU/R284_2_PC110: C362.1 (+), C365.1 (+), C403.2 (-), C405.2 (-), F6.2, F7.2, F9.2, R575.2 (-), R628.2 (-), U88.5 (D), U88.6 (D), U88.7 (D), U88.8 (D), U89.5 (D), U89.6 (D), U92.5 (D), U92.6 (D), U92.7 (D), U92.8 (D)
/PSU/R412_1_PC110: J19.2, R581.2 (-)
/PSU/U21_131_PC110: R514.2 (-), R612.2 (-)
/PSU/U54_1D_PC110: R560.2 (-), R578.2 (-)
/PSU/U54_1Q_PC110: R548.2 (-), R614.2 (-)
/PSU/U54_D: R578.1 (+)
/PSU/U54_Q: R614.1 (+)
/PSU/U54_VCC_PC110: C408.2 (-), Q55.2 (B), Q72.1 (OUT), R577.2 (-), SW3.1
D4_3: R606.1 (+); also elsewhere on the board
D18_2_3: R617.1 (+); also elsewhere on the board
D28_1: R573.1 (+); also elsewhere on the board
D46_1: R603.1 (+); also elsewhere on the board
Dock_PWR_IN-: R605.1 (+); also elsewhere on the board
F65_ENAVEE: R613.1 (+); also elsewhere on the board
GND: C362.2 (-), C365.2 (-), C366.2 (-), C367.2 (-), C368.2 (-), C369.1 (+), C370.1 (+), C371.2 (-), C374.2 (-), C376.1 (+), C378.2 (-), C380.2 (-), C381.1 (+), C382.1 (+), C383.1 (+), C384.2 (-), C388.1 (+), C390.2 (-), C393.1 (+), C395.2 (-), C397.2 (-), C398.2 (-), C400.1 (+), C401.2 (-), C403.1 (+), C404.1 (+), C405.1 (+), C407.1 (+), C408.1 (+), C411.1 (+), C412.1 (+), C413.1 (+), C416.1 (+), C417.2 (-), C418.2 (-), C419.1 (+), C420.1 (+), C421.1 (+), C422.2 (-), C423.2 (-), C425.1 (+), C427.2 (-), C428.1 (+), D64.1 (+), D67.1 (+), J19.3, Q47.2 (GND), Q48.2 (GND), Q49.2 (E), Q50.2 (E), Q53.2 (E), Q54.2 (E), Q56.2 (E), Q62.2 (E), Q63.2 (E), Q64.2 (E), Q65.2 (S), Q69.2 (A), Q70.1 (A), Q70.3 (A), Q72.2 (GND), Q75.2 (E), Q76.2 (E), Q79.1 (A), Q80.1 (K-), Q82.3 (E), Q83.1 (K), Q83.3 (K), R500.2 (-), R510.2 (-), R513.1 (+), R516.1 (+), R522.2 (-), R526.2 (-), R529.1 (+), R531.2 (-), R534.2 (-), R536.2 (-), R542.2 (-), R546.2 (-), R550.1 (+), R552.2 (-), R553.1 (+), R559.1 (+), R561.1 (+), R584.1 (+), R588.2 (-), R589.1 (+), R594.1 (+), R596.1 (+), R598.1 (+), R599.2 (-), R600.1 (+), R605.2 (-), R618.2 (-), R620.1 (+), R622.1 (+), R631.2 (-), R636.2 (-), R638.2 (-), R641.2 (-), U81.4 (GND), U82.8 (GND), U83.3 (GND), U84.2 (GND), U85.4 (V-), U86.11 (V-), U89.1 (S), U90.4 (D1), U90.5 (D2), U90.9 (GND), U90.11 (SYNC), U90.20 (PGND), U91.3 (GND), U93.1 (S), U93.2 (S), U93.3 (S); also elsewhere on the board
JRC_VCC: C398.1 (+), C401.1 (+), Q55.3 (E), R625.1 (+), U85.8 (V+), U86.4 (V+)
M38_P20: R580.1 (+); also elsewhere on the board
M38_P21: R616.1 (+); also elsewhere on the board
M38_P52: R579.1 (+); also elsewhere on the board
M38_P53: R615.1 (+); also elsewhere on the board
M38_P60: R567.1 (+); also elsewhere on the board
M38_P61: R568.1 (+); also elsewhere on the board
M38_P63: R602.1 (+); also elsewhere on the board
M38_P64: R607.1 (+); also elsewhere on the board
M38_VREF: R609.1 (+); also elsewhere on the board
unnamed: C363.1 (+), R503.2 (-)
unnamed: C363.2 (-), R501.2 (-), U81.2
unnamed: C364.1 (+), R504.2 (-), U81.5, U81.7
unnamed: C364.2 (-), R505.2 (-)
unnamed: C367.1 (+), F6.1, L77.2 (-)
unnamed: C368.1 (+), F7.1, L78.1 (+)
unnamed: C372.1 (+), Q51.3 (E), R507.1 (+), R509.1 (+), R510.1 (+), U82.3 (NON1)
unnamed: C373.1 (+), C375.1 (+), U82.5 (FB1)
unnamed: C373.2 (-), R508.2 (-)
unnamed: C375.2 (-), R508.1 (+), R525.2 (-), R526.1 (+), U82.4 (INV1)
unnamed: C376.2 (-), Q51.1 (C), R519.2 (-), U82.7 (OUT1)
unnamed: C377.1 (+), Q52.3 (E), R515.1 (+), R516.2 (-), U82.14 (NON2)
unnamed: C378.1 (+), Q52.1 (C), R514.1 (+)
unnamed: C379.1 (+), R521.1 (+)
unnamed: C379.2 (-), R523.1 (+), U82.12 (FB2)
unnamed: C380.1 (+), C382.2 (-), C385.1 (+), C386.2 (-), Q51.2 (B), Q52.2 (B), R524.2 (-), R525.1 (+), R527.2 (-), R528.1 (+), U82.16 (VREF)
unnamed: C383.2 (-), U82.15 (SCP)
unnamed: C384.1 (+), R532.2 (-), U82.9 (VCC)
unnamed: C385.2 (-), R527.1 (+), R536.1 (+), U82.11 (DT2)
unnamed: C386.1 (+), R528.2 (-), R529.2 (-), U82.6 (DT1)
unnamed: C387.1 (+), R540.2 (-), R541.1 (+), U83.2, U83.5
unnamed: C387.2 (-), Q59.3 (C), R540.1 (+)
unnamed: C388.2 (-), R538.1 (+), U82.1 (CT)
unnamed: C389.1 (+), R543.1 (+), R547.1 (+), U85.2 (-)
unnamed: C389.2 (-), Q60.1 (K), R543.2 (-), U85.1
unnamed: C390.1 (+), R544.1 (+), R545.1 (+), R546.1 (+), U85.3 (+)
unnamed: C391.2 (-), R549.2 (-), R554.2 (-), U86.2 (-)
unnamed: C392.1 (+), R551.2 (-)
unnamed: C393.2 (-), R551.1 (+)
unnamed: C394.1 (+), Q62.3 (C), R564.2 (-)
unnamed: C394.2 (-), C395.1 (+), Q62.1 (B), R548.1 (+)
unnamed: C396.1 (+), R552.1 (+), R556.1 (+), U86.3 (+)
unnamed: C396.2 (-), Q67.1 (C), R556.2 (-)
unnamed: C397.1 (+), Q65.1 (G), R560.1 (+)
unnamed: C399.2 (-), Q69.3 (K), R557.1 (+), R563.2 (-), U86.9 (-)
unnamed: C400.2 (-), R582.1 (+), R583.1 (+)
unnamed: C402.1 (+), L79.2 (-), R582.2 (-), R583.2 (-), R585.2 (-)
unnamed: C402.2 (-), R585.1 (+), R620.2 (-), R622.2 (-), U90.1 (CS3)
unnamed: C406.2 (-), Q66.3 (D), R564.1 (+), R587.2 (-), U88.4 (G)
unnamed: C407.2 (-), F8.2, L80.1 (+), Q67.3 (E), R584.2 (-), R593.2 (-)
unnamed: C409.2 (-), R601.2 (-), R618.1 (+), U90.28 (FB3)
unnamed: C410.2 (-), R600.2 (-), R619.2 (-), U86.13 (-)
unnamed: C411.2 (-), D67.2 (-), Q72.3 (IN), Q74.3 (C)
unnamed: C412.2 (-), U90.2 (SS3)
unnamed: C413.2 (-), F9.1, J19.4
unnamed: C414.1 (+), L79.1 (+), Q70.2 (K), U89.3 (1), U89.7 (D), U89.8 (D), U90.26 (LX3)
unnamed: C414.2 (-), Q78.3 (K), U90.25 (BST3)
unnamed: C415.1 (+), R623.2 (-), U85.6 (-)
unnamed: C415.2 (-), Q60.3 (K), U85.7
unnamed: C416.2 (-), R628.1 (+), U90.23 (V+)
unnamed: C417.1 (+), Q80.3 (G), R635.2 (-), R636.1 (+)
unnamed: C418.1 (+), U90.10 (REF)
unnamed: C419.2 (-), R637.2 (-), U90.3 (ON3), U90.6 (VH), U90.12 (SHDN#), U90.13 (ON5)
unnamed: C421.2 (-), Q78.2 (A), R637.1 (+), U90.22 (VL)
unnamed: C422.1 (+), R627.1 (+), R634.1 (+), U91.2 (VDD)
unnamed: C423.1 (+), U90.14 (SS5)
unnamed: C424.1 (+), L81.2 (-), Q83.2 (A), U90.17 (LX5), U92.1 (S), U92.2 (S), U92.3 (S), U93.5 (D), U93.6 (D), U93.7 (D), U93.8 (D)
unnamed: C424.2 (-), Q78.1 (K), U90.18 (BST5)
unnamed: C426.1 (+), J20.2, R641.1 (+), R646.2 (-)
unnamed: C426.2 (-), F10.1, R640.1 (+), R646.1 (+)
unnamed: D63.2 (A), Q56.1 (C)
unnamed: D64.2 (-), L80.2 (-), U87.5 (D), U87.6 (D), U87.7 (D), U87.8 (D)
unnamed: D65.1 (K), Q71.2 (K), R621.1 (+)
unnamed: D66.2 (A+), Q74.1 (B), R624.2 (-)
unnamed: D70.2 (A), R635.1 (+)
unnamed: F10.2, J20.1
unnamed: F8.1, JX1.1
unnamed: JX1.2, R550.2 (-), R553.2 (-), R554.1 (+), R557.2 (-), R590.2 (-)
unnamed: L77.1 (+), Q47.3, Q47.5
unnamed: L78.2 (-), Q48.3, Q48.5
unnamed: L81.1 (+), R643.2 (-), R644.2 (-), R645.2 (-), U90.15 (CS5)
unnamed: Q49.1 (B), R506.2 (-)
unnamed: Q49.3 (C), Q53.1 (C), R518.2 (-)
unnamed: Q50.1 (B), R512.2 (-), R513.2 (-), R518.1 (+)
unnamed: Q53.3 (B), Q54.3 (B), Q56.3 (B), R520.2 (-)
unnamed: Q54.1 (C), R517.2 (-)
unnamed: Q55.1 (C), R520.1 (+)
unnamed: Q57.2 (common), R539.1 (+), R541.2 (-), U83.6
unnamed: Q58.1 (B), R535.1 (+)
unnamed: Q58.2 (E), R530.2 (-)
unnamed: Q59.1 (B), R533.1 (+)
unnamed: Q59.2 (E), R537.1 (+), U84.4
unnamed: Q60.2 (A), R530.1 (+), R531.1 (+), U84.1
unnamed: Q61.2 (K), R555.1 (+), R558.2 (-)
unnamed: Q63.1 (B), R555.2 (-)
unnamed: Q63.3 (C), R562.2 (-)
unnamed: Q64.1 (B), R558.1 (+)
unnamed: Q64.3 (C), R566.2 (-)
unnamed: Q65.3 (D), Q66.1 (G), R565.1 (+)
unnamed: Q67.2 (B), R566.1 (+)
unnamed: Q68.3 (B), R586.2 (-)
unnamed: Q68.1 (C), R562.1 (+)
unnamed: Q61.3 (A), Q73.2 (K), R535.2 (-), R642.2 (-)
unnamed: Q75.3 (C), R626.2 (-)
unnamed: Q76.1 (B), R629.1 (+)
unnamed: Q76.3 (C), R624.1 (+)
unnamed: Q77.2 (A), R630.2 (-)
unnamed: Q77.1 (K), R625.2 (-)
unnamed: Q81.1 (B), R639.1 (+)
unnamed: Q81.3 (C), R544.2 (-), R545.2 (-), R633.2 (-)
unnamed: Q82.2 (B), R639.2 (-)
unnamed: Q82.1 (C), R642.1 (+)
unnamed: R498.1 (+), U81.1, U81.3, U82.10 (OUT2)
unnamed: R499.1 (+), U81.6
unnamed: R500.1 (+), R502.1 (+), SW3.2
unnamed: Q47.1, R501.1 (+), R503.1 (+)
unnamed: Q48.1, R504.1 (+), R505.1 (+)
unnamed: R511.1 (+), R512.1 (+)
unnamed: R521.2 (-), R522.1 (+), R523.2 (-), R524.1 (+), U82.13 (INV2)
unnamed: R534.1 (+), R539.2 (-)
unnamed: R537.2 (-), R538.2 (-), U84.3
unnamed: R542.1 (+), U82.2 (RT)
unnamed: R559.2 (-), R561.2 (-), U86.10 (+)
unnamed: R586.1 (+), R588.1 (+), U86.5 (+)
unnamed: R589.2 (-), R591.2 (-), R592.2 (-), U86.6 (-)
unnamed: Q69.1 (K), R590.1 (+), R599.1 (+), U86.12 (+)
unnamed: R593.1 (+), R594.2 (-)
unnamed: Q71.3 (A), R595.1 (+), R596.2 (-)
unnamed: Q71.1 (A), R597.2 (-), R598.2 (-)
unnamed: R626.1 (+), R631.1 (+), R633.1 (+), U85.5 (+)
unnamed: R629.2 (-), R632.1 (+), U91.1 (VOUT)
unnamed: R632.2 (-), R634.2 (-)
unnamed: U83.1, U83.4, U87.4 (G)
unnamed: U89.2 (G), U90.24 (DL3)
unnamed: U89.4 (G), U90.27 (DH3)
unnamed: U90.16 (DH5), U92.4 (G)
unnamed: U90.19 (DL5), U93.4 (G)
PNET1: C409.1 (+), R571.1 (+), R601.1 (+), R608.1 (+); also elsewhere on the board
PNET4: R569.1 (+), R604.1 (+); also elsewhere on the board
PNET4_PC110: C392.2 (-), C406.1 (+), D66.1 (K-), D68.1 (K-), D69.1 (K-), Q66.2 (S), Q74.2 (E), R565.2 (-), R569.2 (-), R587.1 (+), R604.2 (-), R627.2 (-), U87.1 (S), U87.2 (S), U87.3 (S), U88.1 (S), U88.2 (S), U88.3 (S)
PNET5: R572.1 (+), R610.1 (+), U90.21 (FB5); also elsewhere on the board
PNET5_PC110: C381.2 (-), C404.2 (-), C427.1 (+), C428.2 (-), Q58.3 (C), Q77.3 (common), R498.2 (-), R499.2 (-), R532.1 (+), R533.2 (-), R572.2 (-), R595.2 (-), R597.1 (+), R610.2 (-), R643.1 (+), R644.1 (+), R645.1 (+), U81.8 (VCC), U84.5 (VCC)
PSU_AUX_SW1: R611.1 (+); also elsewhere on the board
PWR_IN_10v5: C425.2 (-), D68.2 (A+), D69.2 (A+), D70.1 (K), Q57.3 (K), Q68.2 (E), Q80.2 (A+), R511.2 (-), R638.1 (+), R640.2 (-)
Q43_2: R574.1 (+); also elsewhere on the board
R73_2: R576.1 (+); also elsewhere on the board
R284_2: R575.1 (+); also elsewhere on the board
R412_1: R581.1 (+); also elsewhere on the board
U21_131: R612.1 (+); also elsewhere on the board
VCC: R577.1 (+); also elsewhere on the board
YellowWire2_3: R570.1 (+); also elsewhere on the board

Notes on the sheet:
10.5v

Schematic: DockingStation-ports.kicad_sch, PC110 Docking Station

Parts:
C284, C286, C290, C293, C296, C298, C301, C303, C346, C348, C350, C352: 200pF; C_0603_1608Metric
C285, C288, C292, C294, C297, C299, C302, C304, C305, C306, C307, C308, C309, C310, C313, C314, C315: 200nF; C_0603_1608Metric
C287, C327, C331, C332, C333, C334, C335, C338, C344, C347, C349, C353, C358, C359: 280nF; C_0603_1608Metric
C289, C295: 10nF; C_0603_1608Metric
C291: 330nF; C_0603_1608Metric
C300: 150nF; C_0603_1608Metric
C311, C312, C318, C319: 360nF; C_0805_2012Metric
C316, C340, C341: 250nF; C_0603_1608Metric
C317, C323, C324, C325: DNP; C_0603_1608Metric; not fitted
C320, C326: DNP; C_0805_2012Metric; not fitted
C321, C322: DNP; C_1206_3216Metric; not fitted
C328, C329, C330, C336, C342, C351, C354, C355, C357, C360: 82pF; C_0603_1608Metric
C337: 330nF; C_0805_2012Metric
C339: 1nF; C_0805_2012Metric
C343, C345: 200pF; C_0805_2012Metric
C356: 2.5uF; C_1206_3216Metric
C361: 1nF; C_0603_1608Metric
CN1: DSUB-9_Pins_Horizontal_P2.77x2.84mm_EdgePinOffset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; DSUB-9_Pins_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
CN2: DSUB-25_Socket_Horizontal_P2.77x2.84mm_EdgePinOff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; DSUB-25_Socket_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_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
CN3: BarrelJack_Horizontal_PC110
CN4: DSUB-15-HD_Socket_Horizontal_P2.29x1.90mm_EdgePin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; DSUB-15-HD_Socket_Horizontal_P2.29x1.90mm_EdgePinOffset3.03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
CN5, CN6: PS2 Connector
CN7: FDC_Connector
D61, D62: s.3 5J; D_2010_5025Metric
DA1, DA2: DNP; SOT-23W; not fitted
DA3: SOT-323_SC-70; not fitted
DA4, DA5, DA6, DA7, DA8, DA9, DA10, DA11: 1W; SOT-323_SC-70
F5: 50v x1G0 JX30; Fuse_Littelfuse_395Series
L19, L20, L21, L22, L23, L25, L26, L27, L28, L29, L30, L31, L32, L33, L34, L35, L36, L37, L38, L39, L40, L41, L42, L43, L44, L45, L46, L47, L48, L49, L50, L51, L52, L53, L54, L56, L57, L58, L59, L60, L63, L64, L65, L66, L67, L68, L69, L70, L74, L75, L76: 680nH; L_0805_2012Metric
L24: EMI_Transformer
L55, L61, L62, L71, L72, L73: 300nH; L_0805_2012Metric
Q45: 3P4J; TO-252-2
Q46: 8C; SOT-323_SC-70
R425, R427, R430, R433, R436, R439, R444, R447, R465, R469, R470, R472, R473, R474, R476, R480, R482, R485, R487, R489, R493, R495: DNP; R_0603_1608Metric; not fitted
R426, R428, R431, R434, R437, R440, R445, R448, R466, R468, R475, R477, R481, R483, R486, R488, R490, R494, R496: 0; R_0603_1608Metric
R429, R432, R435, R438, R442, R446, R449, R453, R454, R459, R460, R461, R462, R463, R464, R467, R471: 10; R_0603_1608Metric
R441, R443, R450, R451, R452, R456, R457, R458: 1k; R_0805_2012Metric
R455: 0; R_0805_2012Metric
R478, R479: 33; R_0603_1608Metric
R484, R497: 470k; R_0603_1608Metric
R491, R492: 33; R_0805_2012Metric
RA6, RA7: DNP; R_Array_Concave_4x0603; not fitted
RA8, RA9, RA12: 47k; R_Array_Concave_4x0603
RA10, RA11: 470k; R_Array_Concave_4x0603
SSFC1: Fuse_2010_5025Metric
U77: DS14C535MSA; SSOP-28_5.3x10.2mm_P0.65mm
U78: DNP; SOT-23-5; not fitted
U79: DNP (LT1237CS); SSOP-28_5.3x10.2mm_P0.65mm; not fitted
U80: 74VHCT244; SSOP-20_4.4x6.5mm_P0.65mm
ZD1: 18-; D_0805_2012Metric
ZD2: 5_1; D_0805_2012Metric

Connections:
/DockingStation-ports/CTS2#: R484.1 (+), R485.2 (-), R486.1 (+)
/DockingStation-ports/DIN1: R496.2 (-), U77.7 (DIN1)
/DockingStation-ports/DIN2: R494.2 (-), U77.8 (DIN2)
/DockingStation-ports/DIN3: R490.2 (-), U77.9 (DIN3)
/DockingStation-ports/DOUT1: R440.1 (+), U77.22 (DOUT1)
/DockingStation-ports/DOUT2: R434.1 (+), U77.21 (DOUT2)
/DockingStation-ports/DOUT3: R445.1 (+), U77.20 (DOUT3)
/DockingStation-ports/DSR2#: R482.2 (-), R483.1 (+)
/DockingStation-ports/FDD_PWR: C349.2 (-), C353.2 (-), L69.1 (+), RA8.1 (R1.1), RA8.2 (R2.1), RA8.3 (R3.1), RA8.4 (R4.1), RA9.1 (R1.1), RA9.2 (R2.1), RA9.3 (R3.1), RA9.4 (R4.1), RA10.1 (R1.1), RA10.2 (R2.1), RA10.3 (R3.1), RA10.4 (R4.1), RA11.1 (R1.1), RA11.2 (R2.1), RA11.3 (R3.1), RA11.4 (R4.1), RA12.1 (R1.1), RA12.2 (R2.1), RA12.3 (R3.1), RA12.4 (R4.1)
/DockingStation-ports/LT_DR1_IN: R495.1 (+), U79.25 (DR1_IN)
/DockingStation-ports/LT_DR1_OUT: R439.2 (-), U79.5 (DR1_OUT)
/DockingStation-ports/LT_DR2_IN: R493.1 (+), U79.23 (DR2_IN)
/DockingStation-ports/LT_DR2_OUT: R433.2 (-), U79.7 (DR2_OUT)
/DockingStation-ports/LT_DR3_IN: R489.1 (+), U79.19 (DR3_IN)
/DockingStation-ports/LT_DR3_OUT: R444.2 (-), U79.11 (DR3_OUT)
/DockingStation-ports/LT_RX1_IN: R425.2 (-), U79.6 (RX1_IN)
/DockingStation-ports/LT_RX1_OUT: R487.1 (+), U79.24 (RX1_OUT)
/DockingStation-ports/LT_RX2_IN: R430.2 (-), U79.8 (RX2_IN)
/DockingStation-ports/LT_RX2_OUT: R485.1 (+), U79.22 (RX2_OUT)
/DockingStation-ports/LT_RX3_IN: R436.2 (-), U79.9 (RX3_IN)
/DockingStation-ports/LT_RX3_OUT: R482.1 (+), U79.21 (RX3_OUT)
/DockingStation-ports/LT_RX4_IN: R447.2 (-), U79.10 (RX4_IN)
/DockingStation-ports/LT_RX4_OUT: R480.1 (+), U79.20 (RX4_OUT)
/DockingStation-ports/LT_RX5_IN: R427.2 (-), U79.12 (RX5_IN)
/DockingStation-ports/LT_RX5_OUT: R476.2 (-), U79.18 (RX5_OUT)
/DockingStation-ports/M38_P46_PC110: Q46.3 (C)
/DockingStation-ports/M38_P67_PC110: R451.1 (+), R452.2 (-), ZD2.1 (K)
/DockingStation-ports/PD0: R464.1 (+), RA7.8 (R1.2)
/DockingStation-ports/PD1: R462.1 (+), RA7.7 (R2.2)
/DockingStation-ports/PD2: R460.1 (+), RA7.6 (R3.2)
/DockingStation-ports/PD3: R454.1 (+), RA7.5 (R4.2)
/DockingStation-ports/PD4: R453.1 (+), RA6.8 (R1.2)
/DockingStation-ports/PD5: R449.1 (+), RA6.7 (R2.2)
/DockingStation-ports/PD6: R446.2 (-), RA6.6 (R3.2)
/DockingStation-ports/PD7: R442.1 (+), RA6.5 (R4.2)
/DockingStation-ports/PNET5_Q1: C335.2 (-), L55.2 (-)
/DockingStation-ports/PWR_IN+_D: D61.1 (K), D62.1 (K)
/DockingStation-ports/PWR_IN-: C295.2 (-), C300.2 (-), L24.2, Q45.1 (K-), R441.1 (+), R452.1 (+), R458.1 (+), ZD2.2 (A)
/DockingStation-ports/R269_1_PC110: R455.1 (+)
/DockingStation-ports/RI2#: R476.1 (+), R477.2 (-)
/DockingStation-ports/RIN1: R426.1 (+), U77.19 (RIN1)
/DockingStation-ports/RIN2: R431.1 (+), U77.18 (RIN2)
/DockingStation-ports/RIN3: R437.1 (+), U77.17 (RIN3)
/DockingStation-ports/RIN4: R448.1 (+), U77.16 (RIN4)
/DockingStation-ports/RIN5: R428.1 (+), U77.15 (RIN5)
/DockingStation-ports/ROUT1: R488.2 (-), U77.10 (ROUT1)
/DockingStation-ports/ROUT2: R486.2 (-), U77.11 (ROUT2)
/DockingStation-ports/ROUT3: R483.2 (-), U77.12 (ROUT3)
/DockingStation-ports/ROUT4: R481.2 (-), U77.13 (ROUT4)
/DockingStation-ports/ROUT5: R477.1 (+), U77.14 (ROUT5)
/DockingStation-ports/RXD2: R480.2 (-), R481.1 (+)
/DockingStation-ports/VGA_BLUE: DA10.3 (common), L73.1 (+)
/DockingStation-ports/VGA_GREEN: DA9.3 (common), L72.1 (+)
/DockingStation-ports/VGA_Hsync: R478.1 (+)
/DockingStation-ports/VGA_RED: DA8.3 (common), L71.1 (+)
/DockingStation-ports/VGA_Vsync: R479.1 (+)
DS_VCC: C312.1 (+), C316.2 (-), R466.2 (-), R470.1 (+), U77.3 (VCC)
EN_RS232: R468.1 (+), R469.2 (-); also elsewhere on the board
FDC_ACK#: R438.1 (+); also elsewhere on the board
FDC_AUTOFD#: R467.1 (+); also elsewhere on the board
FDC_BUSY: R435.1 (+); also elsewhere on the board
FDC_DCD2#: R487.2 (-), R488.1 (+); also elsewhere on the board
FDC_DIR#: L68.1 (+), RA10.6 (R3.2); also elsewhere on the board
FDC_DRATE0#: L52.1 (+), RA11.5 (R4.2); also elsewhere on the board
FDC_DRATE1#: L76.1 (+), RA11.8 (R1.2); also elsewhere on the board
FDC_DSKCHG#: L45.1 (+), RA8.5 (R4.2); also elsewhere on the board
FDC_DTR2#: R495.2 (-), R496.1 (+); also elsewhere on the board
FDC_ERROR#: R463.1 (+); also elsewhere on the board
FDC_HDSEL#: L46.1 (+), RA8.6 (R3.2); also elsewhere on the board
FDC_INDEX#: L53.1 (+), RA12.8 (R1.2); also elsewhere on the board
FDC_INIT#: R461.1 (+); also elsewhere on the board
FDC_IRTX_TXD2: R489.2 (-), R490.1 (+); also elsewhere on the board
FDC_PE: R432.1 (+); also elsewhere on the board
FDC_Pluto1: L54.1 (+), RA11.7 (R2.2); also elsewhere on the board
FDC_Pluto2: L75.1 (+), RA11.6 (R3.2); also elsewhere on the board
FDC_Pluto3: L51.1 (+), RA10.7 (R2.2); also elsewhere on the board
FDC_Pluto4: L66.1 (+), RA10.5 (R4.2); also elsewhere on the board
FDC_RDATA#: L58.1 (+); also elsewhere on the board
FDC_RTS2#: R493.2 (-), R494.1 (+); also elsewhere on the board
FDC_SLCT: R429.1 (+); also elsewhere on the board
FDC_SLCTIN#: R459.1 (+); also elsewhere on the board
FDC_STEP#: L50.1 (+), RA9.8 (R1.2); also elsewhere on the board
FDC_STROBE#: R471.1 (+); also elsewhere on the board
FDC_TRK0#: L48.1 (+), RA9.5 (R4.2); also elsewhere on the board
FDC_WDATA#: L67.1 (+), RA9.7 (R2.2); also elsewhere on the board
FDC_WGATE#: L49.1 (+), RA9.6 (R3.2); also elsewhere on the board
FDC_WRTPRT#: L47.1 (+), RA8.8 (R1.2); also elsewhere on the board
FDD_Bowman: L56.2 (-); also elsewhere on the board
FDD_DRSEL: L74.1 (+), RA12.7 (R2.2); also elsewhere on the board
FDD_MOTEN: L70.1 (+), RA12.6 (R3.2); also elsewhere on the board
GND: C284.2 (-), C285.1 (+), C286.2 (-), C287.2 (-), C288.1 (+), C290.2 (-), C291.2 (-), C292.1 (+), C293.2 (-), C294.1 (+), C296.2 (-), C297.1 (+), C298.2 (-), C299.1 (+), C301.2 (-), C302.1 (+), C303.1 (+), C304.1 (+), C305.1 (+), C306.1 (+), C307.1 (+), C308.1 (+), C309.1 (+), C310.1 (+), C313.1 (+), C314.1 (+), C315.1 (+), C316.1 (+), C317.1 (+), C319.2 (-), C321.2 (-), C322.2 (-), C323.2 (-), C324.2 (-), C325.2 (-), C327.1 (+), C328.2 (-), C329.2 (-), C330.2 (-), C331.1 (+), C332.1 (+), C333.1 (+), C334.1 (+), C335.1 (+), C336.2 (-), C337.1 (+), C338.1 (+), C339.1 (+), C340.2 (-), C341.2 (-), C342.2 (-), C343.2 (-), C344.1 (+), C345.2 (-), C346.1 (+), C347.1 (+), C348.1 (+), C349.1 (+), C350.1 (+), C351.2 (-), C352.1 (+), C353.1 (+), C354.2 (-), C355.2 (-), C356.1 (+), C357.2 (-), C358.1 (+), C359.1 (+), C360.2 (-), C361.1 (+), CN1.5, CN4.5, CN4.6, CN4.7, CN4.8, CN5.3, CN6.3, CN7.1, CN7.3, CN7.4, CN7.10, DA3.2 (A), DA6.1 (K), DA7.1 (K), DA8.1 (K), DA9.1 (K), DA10.1 (K), DA11.2 (A), Q46.2 (E), R474.1 (+), R475.1 (+), R484.2 (-), R497.1 (+), U77.5 (GND), U77.27 (GND), U78.3 (GND), U79.17 (GND), U80.1 (1OE), U80.10 (GND), U80.19 (2OE); also elsewhere on the board
KB_INIT1: L64.2 (-); also elsewhere on the board
KB_INIT2: L63.2 (-); also elsewhere on the board
KB_INIT3: L60.2 (-); also elsewhere on the board
KB_INIT4: L59.2 (-); also elsewhere on the board
unnamed: C284.1 (+), CN1.1, L19.2 (-)
unnamed: C285.2 (-), CN2.13, L20.2 (-)
unnamed: C286.1 (+), CN1.9, L21.2 (-)
unnamed: C288.2 (-), CN2.12, L22.2 (-)
unnamed: C289.1 (+), CN3.2, L24.1
unnamed: C289.2 (-), CN3.1, L24.3
unnamed: C290.1 (+), CN1.8, L23.2 (-)
unnamed: C292.2 (-), CN2.11, L25.2 (-)
unnamed: C293.1 (+), CN1.7, L26.2 (-)
unnamed: C294.2 (-), CN2.10, L27.2 (-)
unnamed: C295.1 (+), F5.1 (+), L24.4, SSFC1.1 (+)
unnamed: C296.1 (+), CN1.6, L28.2 (-)
unnamed: C297.2 (-), CN2.9, L29.2 (-)
unnamed: C298.1 (+), CN1.4, L30.2 (-)
unnamed: C299.2 (-), CN2.8, L31.2 (-)
unnamed: C300.1 (+), Q45.3 (G), R441.2 (-), R443.1 (+)
unnamed: C301.1 (+), CN1.3, L32.2 (-)
unnamed: C302.2 (-), CN2.7, L33.2 (-)
unnamed: C303.2 (-), CN1.2, L34.2 (-)
unnamed: C304.2 (-), CN2.6, L35.2 (-)
unnamed: C305.2 (-), CN2.5, L36.2 (-)
unnamed: C306.2 (-), CN2.17, L37.2 (-)
unnamed: C307.2 (-), CN2.4, L38.2 (-)
unnamed: C308.2 (-), CN2.16, L39.2 (-)
unnamed: C309.2 (-), CN2.3, L40.2 (-)
unnamed: C310.2 (-), CN2.15, L41.2 (-)
unnamed: C311.1 (+), U77.4 (C1-)
unnamed: C311.2 (-), U77.2 (C1+)
unnamed: C312.2 (-), U77.1 (V+)
unnamed: C313.2 (-), CN2.2, L42.2 (-)
unnamed: C314.2 (-), CN2.14, L43.2 (-)
unnamed: C315.2 (-), CN2.1, L44.2 (-)
unnamed: C317.2 (-), R465.2 (-), U78.5 (VCC)
unnamed: C318.1 (+), U77.28 (C2+)
unnamed: C318.2 (-), U77.26 (C2-)
unnamed: C319.1 (+), U77.25 (V-)
unnamed: C320.1 (+), U79.4 (C1-)
unnamed: C320.2 (-), U79.3 (C1+)
unnamed: C321.1 (+), C322.1 (+), U79.1 (V+)
unnamed: C323.1 (+), R472.2 (-), R473.1 (+), U79.2 (VCC)
unnamed: C324.1 (+), C325.1 (+), U79.28 (V-)
unnamed: C326.1 (+), U79.26 (C2+)
unnamed: C326.2 (-), U79.27 (C2-)
unnamed: C327.2 (-), CN7.26, L45.2 (-)
unnamed: C328.1 (+), CN7.25, L46.2 (-)
unnamed: C329.1 (+), CN7.24, L47.2 (-)
unnamed: C330.1 (+), CN7.23, L48.2 (-)
unnamed: C331.2 (-), CN7.22, L49.2 (-)
unnamed: C332.2 (-), CN7.21, L50.2 (-)
unnamed: C333.2 (-), CN7.20, L51.2 (-)
unnamed: C334.2 (-), CN7.19, L52.2 (-)
unnamed: C336.1 (+), CN7.17, L53.2 (-)
unnamed: C338.2 (-), CN7.15, L54.2 (-)
unnamed: C340.1 (+), C341.1 (+), L55.1 (+), L61.2 (-), L62.2 (-)
unnamed: C342.1 (+), CN7.13, L56.1 (+)
unnamed: C343.1 (+), CN4.14, L57.2 (-)
unnamed: C344.2 (-), CN7.12, L58.2 (-)
unnamed: C345.1 (+), CN4.13, L65.2 (-)
unnamed: C346.2 (-), CN5.1, CN6.2, L59.1 (+)
unnamed: C347.2 (-), CN7.11, L66.2 (-)
unnamed: C348.2 (-), CN6.1, L64.1 (+)
unnamed: C350.2 (-), CN5.5, CN6.6, L60.1 (+)
unnamed: C351.1 (+), CN7.9, L67.2 (-)
unnamed: C352.2 (-), CN6.5, L63.1 (+)
unnamed: C354.1 (+), CN7.8, L68.2 (-)
unnamed: C355.1 (+), CN7.7, L70.2 (-)
unnamed: C356.2 (-), C359.2 (-), C361.2 (-), CN7.2, CN7.18, L69.2 (-), R497.2 (-)
unnamed: C357.1 (+), CN7.6, L74.2 (-)
unnamed: C358.2 (-), CN7.5, L75.2 (-)
unnamed: C360.1 (+), CN7.14, L76.2 (-)
unnamed: CN2.18, CN2.19, CN2.20, CN2.21, CN2.22, CN2.23, CN2.24, CN2.25
unnamed: D61.2 (A), D62.2 (A), F5.2 (-), Q45.2 (A+), R450.2 (-), R455.2 (-), R456.2 (-), SSFC1.2 (-), ZD1.1 (K)
unnamed: DA1.3 (K), RA6.1 (R1.1), RA6.2 (R2.1), RA6.3 (R3.1), RA6.4 (R4.1)
unnamed: DA2.3 (K), RA7.1 (R1.1), RA7.2 (R2.1), RA7.3 (R3.1), RA7.4 (R4.1)
unnamed: DA3.1 (K), DA4.2 (A), R475.2 (-)
unnamed: DA4.1 (K), DA5.2 (A)
unnamed: DA5.1 (K), DA6.2 (A), DA7.2 (A)
unnamed: DA6.3 (common), R479.2 (-), U80.11 (2A3), U80.13 (2A2), U80.15 (2A1), U80.17 (2A0)
unnamed: DA7.3 (common), R478.2 (-), U80.2 (1A0), U80.4 (1A1), U80.6 (1A2), U80.8 (1A3)
unnamed: DA8.2 (A), DA9.2 (A), DA10.2 (A), DA11.1 (K)
unnamed: L19.1 (+), R425.1 (+), R426.2 (-)
unnamed: L20.1 (+), R429.2 (-)
unnamed: L21.1 (+), R427.1 (+), R428.2 (-)
unnamed: L22.1 (+), R432.2 (-)
unnamed: L23.1 (+), R430.1 (+), R431.2 (-)
unnamed: L25.1 (+), R435.2 (-)
unnamed: L26.1 (+), R433.1 (+), R434.2 (-)
unnamed: L27.1 (+), R438.2 (-)
unnamed: L28.1 (+), R436.1 (+), R437.2 (-)
unnamed: L29.1 (+), R442.2 (-)
unnamed: L30.1 (+), R439.1 (+), R440.2 (-)
unnamed: L31.1 (+), R446.1 (+)
unnamed: L32.1 (+), R444.1 (+), R445.2 (-)
unnamed: L33.1 (+), R449.2 (-)
unnamed: L34.1 (+), R447.1 (+), R448.2 (-)
unnamed: L35.1 (+), R453.2 (-)
unnamed: L36.1 (+), R454.2 (-)
unnamed: L37.1 (+), R459.2 (-)
unnamed: L38.1 (+), R460.2 (-)
unnamed: L39.1 (+), R461.2 (-)
unnamed: L40.1 (+), R462.2 (-)
unnamed: L41.1 (+), R463.2 (-)
unnamed: L42.1 (+), R464.2 (-)
unnamed: L43.1 (+), R467.2 (-)
unnamed: L44.1 (+), R471.2 (-)
unnamed: L57.1 (+), R492.2 (-)
unnamed: CN5.4, L61.1 (+)
unnamed: CN6.4, L62.1 (+)
unnamed: L65.1 (+), R491.2 (-)
unnamed: CN4.1, L71.2 (-)
unnamed: CN4.2, L72.2 (-)
unnamed: CN4.3, L73.2 (-)
unnamed: Q46.1 (B), R457.1 (+), R458.2 (-)
unnamed: R443.2 (-), ZD1.2 (A)
unnamed: R450.1 (+), R451.2 (-)
unnamed: R456.1 (+), R457.2 (-)
unnamed: R468.2 (-), U77.23 (SHUTDOWN)
unnamed: R469.1 (+), U78.2
unnamed: R474.2 (-), U79.16 (DRV_DIS)
unnamed: R491.1 (+), U80.12 (1Y3), U80.14 (1Y2), U80.16 (1Y1), U80.18 (1Y0)
unnamed: R492.1 (+), U80.3 (2Y0), U80.5 (2Y1), U80.7 (2Y2), U80.9 (2Y3)
unnamed: U78.4, U79.13 (ON/OFF)
PNET2: C287.1 (+), C291.1 (+), C337.2 (-), C339.2 (-), DA1.1 (A), DA1.2 (A), DA2.1 (A), DA2.2 (A), R470.2 (-), R473.2 (-), U80.20 (VCC); also elsewhere on the board
PNET5: R465.1 (+), R466.1 (+), R472.1 (+); also elsewhere on the board

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
Board: 2 copper layers, 1483 parts (0 on the bottom side), 1466 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4_Pad_Via

## KiCad design Mods/PC110-ITX/PC110.kicad_pcb

File Mods/PC110-ITX/README.md:

## PC110-ITX Form Factor

This is an effort to build an ITX form factor motherboard with all the PC110 components, but the BGA parts have been converted to QFP alternatives.

Here is how the netlist looked before the placement.

And here is when the placement has been performed.

Also, here is a 3D render of the board.

Schematic: Processor.kicad_sch, PC110

Parts:
C107: 1nF; C_0402_1005Metric
C112: 150nF; C_0402_1005Metric
J9: Debug-10
J12: Debug-6
R252: 33; R_0402_1005Metric
R253: DNP; R_0402_1005Metric
R395: 10k; R_0402_1005Metric
RA3: 22k; R-array
RA4: 10k; R-array
U76: PGA168

Connections:
CPU_A2: U76.Q14 (A2); also elsewhere on the board
CPU_A3: U76.R15 (A3); also elsewhere on the board
CPU_A4: U76.S16 (A4); also elsewhere on the board
CPU_A5: U76.Q12 (A5); also elsewhere on the board
CPU_A6: U76.S15 (A6); also elsewhere on the board
CPU_A7: U76.Q13 (A7); also elsewhere on the board
CPU_A8: U76.R13 (A8); also elsewhere on the board
CPU_A9: U76.Q11 (A9); also elsewhere on the board
CPU_A10: U76.S13 (A10); also elsewhere on the board
CPU_A11: U76.R12 (A11); also elsewhere on the board
CPU_A12: U76.S7 (A12); also elsewhere on the board
CPU_A13: U76.Q10 (A13); also elsewhere on the board
CPU_A14: U76.S5 (A14); also elsewhere on the board
CPU_A15: U76.R7 (A15); also elsewhere on the board
CPU_A16: U76.Q9 (A16); also elsewhere on the board
CPU_A17: U76.Q3 (A17); also elsewhere on the board
CPU_A18: U76.R5 (A18); also elsewhere on the board
CPU_A19: U76.Q4 (A19); also elsewhere on the board
CPU_A20: U76.Q8 (A20); also elsewhere on the board
CPU_A20M#: J9.7, U76.D15 (A20M#); also elsewhere on the board
CPU_A21: U76.Q5 (A21); also elsewhere on the board
CPU_A22: U76.Q7 (A22); also elsewhere on the board
CPU_A23: U76.S3 (A23); also elsewhere on the board
CPU_A24: U76.Q6 (A24); also elsewhere on the board
CPU_A25: U76.R2 (A25); also elsewhere on the board
CPU_A31: J12.6, U76.Q1 (A31); also elsewhere on the board
CPU_ADS#: U76.S17 (ADS#); also elsewhere on the board
CPU_AHOLD: J12.5, U76.A17 (AHOLD); also elsewhere on the board
CPU_BE0#: J9.6, U76.K15 (BE0#); also elsewhere on the board
CPU_BE1#: J9.3, U76.J16 (BE1#); also elsewhere on the board
CPU_BE2#: J9.8, U76.J15 (BE2#); also elsewhere on the board
CPU_BE3#: J9.5, U76.F17 (BE3#); also elsewhere on the board
CPU_BLAST#: J12.1, U76.R16 (BLAST#); also elsewhere on the board
CPU_BRDY#: J9.2, U76.H15 (BRDY#); also elsewhere on the board
CPU_BS16#: U76.C17 (BS16#); also elsewhere on the board
CPU_D0: U76.P1 (D0); also elsewhere on the board
CPU_D1: U76.N2 (D1); also elsewhere on the board
CPU_D2: U76.N1 (D2); also elsewhere on the board
CPU_D3: U76.H2 (D3); also elsewhere on the board
CPU_D4: U76.M3 (D4); also elsewhere on the board
CPU_D5: U76.J2 (D5); also elsewhere on the board
CPU_D6: U76.L2 (D6); also elsewhere on the board
CPU_D7: U76.L3 (D7); also elsewhere on the board
CPU_D8: U76.F2 (D8); also elsewhere on the board
CPU_D9: U76.D1 (D9); also elsewhere on the board
CPU_D10: U76.E3 (D10); also elsewhere on the board
CPU_D11: U76.C1 (D11); also elsewhere on the board
CPU_D12: U76.G3 (D12); also elsewhere on the board
CPU_D13: U76.D2 (D13); also elsewhere on the board
CPU_D14: U76.K3 (D14); also elsewhere on the board
CPU_D15: U76.F3 (D15); also elsewhere on the board
CPU_D16: U76.J3 (D16); also elsewhere on the board
CPU_D17: U76.D3 (D17); also elsewhere on the board
CPU_D18: U76.C2 (D18); also elsewhere on the board
CPU_D19: U76.B1 (D19); also elsewhere on the board
CPU_D20: U76.A1 (D20); also elsewhere on the board
CPU_D21: U76.B2 (D21); also elsewhere on the board
CPU_D22: U76.A2 (D22); also elsewhere on the board
CPU_D23: U76.A4 (D23); also elsewhere on the board
CPU_D24: U76.A6 (D24); also elsewhere on the board
CPU_D25: U76.B6 (D25); also elsewhere on the board
CPU_D26: U76.C7 (D26); also elsewhere on the board
CPU_D27: U76.C6 (D27); also elsewhere on the board
CPU_D28: U76.C8 (D28); also elsewhere on the board
CPU_D29: U76.A8 (D29); also elsewhere on the board
CPU_D30: U76.C9 (D30); also elsewhere on the board
CPU_D31: U76.B8 (D31); also elsewhere on the board
CPU_DC#: U76.M15 (DC#); also elsewhere on the board
CPU_EADS#: J12.4, U76.B17 (EADS#); also elsewhere on the board
CPU_FLUSH#: J12.2, U76.C15 (FLUSH#); also elsewhere on the board
CPU_HLDA: J9.4, U76.P15 (HLDA); also elsewhere on the board
CPU_HOLD: J9.1, U76.E15 (HOLD); also elsewhere on the board
CPU_INTR: U76.A16 (INTR); also elsewhere on the board
CPU_KEN#: J12.3, U76.F15 (KEN#); also elsewhere on the board
CPU_MIO#: U76.N16 (MIO#); also elsewhere on the board
CPU_NMI: J9.10, U76.A15 (NMI); also elsewhere on the board
CPU_RDY#: U76.F16 (RDY#); also elsewhere on the board
CPU_RESET: U76.C16 (RSTCPU); also elsewhere on the board
CPU_SMI#: U76.B10 (SMI#); also elsewhere on the board
CPU_SMIACT#: U76.C12 (SMIACT#); also elsewhere on the board
CPU_SRESET: J9.9, U76.C10 (SRESET); also elsewhere on the board
CPU_STPCLK#: U76.G15 (STPCLK#); also elsewhere on the board
CPU_WR#: U76.N17 (WR#); also elsewhere on the board
Chipset_CPU_CLK: R252.1; also elsewhere on the board
Chipset_CPU_CLK_Sense: R253.2; also elsewhere on the board
GND: C107.1, C112.1, R395.1, RA3.5 (R4.2), RA3.6 (R3.2), RA3.7 (R2.2), RA3.8 (R1.2), RA4.5 (R4.2), RA4.6 (R3.2), RA4.7 (R2.2), RA4.8 (R1.2), U76.A7 (GND), U76.A9 (GND), U76.A11 (GND), U76.B3 (GND), U76.B4 (GND), U76.B5 (GND), U76.E1 (GND), U76.E17 (GND), U76.G1 (GND), U76.G17 (GND), U76.H1 (GND), U76.H17 (GND), U76.K1 (GND), U76.K17 (GND), U76.L1 (GND), U76.L17 (GND), U76.M1 (GND), U76.M17 (GND), U76.P17 (GND), U76.R4 (GND), U76.S6 (GND), U76.S8 (GND), U76.S9 (GND), U76.S10 (GND), U76.S11 (GND), U76.S12 (GND); also elsewhere on the board
unnamed: RA3.1 (R1.1), U76.A5 (DP3)
unnamed: RA3.2 (R2.1), U76.H3 (DP2)
unnamed: RA3.3 (R3.1), U76.F1 (DP1)
unnamed: RA3.4 (R4.1), U76.N3 (DP0)
unnamed: RA4.1 (R1.1), U76.S2 (A26)
unnamed: RA4.2 (R2.1), U76.S1 (A27)
unnamed: RA4.3 (R3.1), U76.R1 (A28)
unnamed: RA4.4 (R4.1), U76.P2 (A29)
unnamed: R395.2, U76.P3 (A30)
unnamed: R252.2, R253.1, U76.C3 (CLK_CPU)
PNET1: C107.2, C112.2, U76.B7 (VCC), U76.B9 (VCC), U76.B11 (VCC), U76.C4 (VCC), U76.C5 (VCC), U76.E2 (VCC), U76.E16 (VCC), U76.G2 (VCC), U76.G16 (VCC), U76.H16 (VCC), U76.J1 (VCC), U76.K2 (VCC), U76.K16 (VCC), U76.L16 (VCC), U76.M2 (VCC), U76.M16 (VCC), U76.P16 (VCC), U76.Q2 (VCC), U76.R3 (VCC), U76.R6 (VCC), U76.R9 (VCC), U76.R10 (VCC), U76.R11 (VCC), U76.R14 (VCC); also elsewhere on the board

Notes on the sheet:
CPU_ADDRESS_BUS
CPU_DATA_BUS
