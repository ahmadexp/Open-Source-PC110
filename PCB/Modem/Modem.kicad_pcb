# Repository ahmadexp/Open-Source-PC110 (continued)

## KiCad design Mods/PC110-ITX/PC110.kicad_pcb (continued)

Schematic: Chipset.kicad_sch, PC110

Parts:
C8, C35, C253: 150nF; C_0402_1005Metric
C69, C77, C81, C252: 1nF; C_0402_1005Metric
C70, C75, C76, C82: 100nF; C_0402_1005Metric
C73: 120nF; C_0402_1005Metric
C79: 1uF; C_0603_1608Metric
C80: 1uF; C_0603_1608Metric; not fitted
C250, C251: 18pF; C_0402_1005Metric
D21: 3D
D23: 92; D_0603_1608Metric
D58: K; SOT-416L
J4: connector-4
J14: TestPoint_Pad_D1.5mm
R31: 300; R_0402_1005Metric
R49, R57, R116, R401, R404, R405, R406: 100k; R_0402_1005Metric
R96, R246, R249: 47k; R_0402_1005Metric
R248: 470k; R_0402_1005Metric
R251, R318, R322, R324, R326, R329, R333, R334, R335, R337, R338, R342, R343, R345, R346, R347, R352: 33; R_0402_1005Metric
R308: 10; R_0402_1005Metric
R323: 1k; R_0402_1005Metric
R400, R402, R403: DNP; R_0402_1005Metric; not fitted
U7: HD151015; TSSOP-24_6.1x7.8mm_P0.65mm
U19: 7W126; sso-8
U58: EA; SOT-353
U61: QFP208
X3: 32768; XTAL-3

Connections:
/Chipset/CMOS_BATT+: C8.1, J4.3, R31.2
AEN: U61.21 (AEN); also elsewhere on the board
Bowman1: U61.78 (Bowman1); also elsewhere on the board
Bowman2: U61.75 (Bowman2); also elsewhere on the board
Bowman3: U61.76 (Bowman3); also elsewhere on the board
Bowman4: U61.77 (Bowman4); also elsewhere on the board
Bowman5: R57.1, U7.3 (A0), U61.61 (Bowman5); also elsewhere on the board
Bowman5_Buff: U7.22 (B0); also elsewhere on the board
CMOS_BATT_Sense: J4.4; also elsewhere on the board
CPU_A2: U61.83 (CPUA2); also elsewhere on the board
CPU_A3: U61.84 (CPUA3); also elsewhere on the board
CPU_A4: U61.85 (CPUA4); also elsewhere on the board
CPU_A5: U61.86 (CPUA5); also elsewhere on the board
CPU_A6: U61.87 (CPUA6); also elsewhere on the board
CPU_A7: U61.88 (CPUA7); also elsewhere on the board
CPU_A8: U61.89 (CPUA8); also elsewhere on the board
CPU_A9: U61.90 (CPUA9); also elsewhere on the board
CPU_A10: U61.91 (CPUA10); also elsewhere on the board
CPU_A11: U61.92 (CPUA11); also elsewhere on the board
CPU_A12: U61.93 (CPUA12); also elsewhere on the board
CPU_A13: U61.95 (CPUA13); also elsewhere on the board
CPU_A14: U61.96 (CPUA14); also elsewhere on the board
CPU_A15: U61.97 (CPUA15); also elsewhere on the board
CPU_A16: U61.98 (CPUA16); also elsewhere on the board
CPU_A17: U61.99 (CPUA17); also elsewhere on the board
CPU_A18: U61.100 (CPUA18); also elsewhere on the board
CPU_A19: U61.101 (CPUA19); also elsewhere on the board
CPU_A20: U61.102 (CPUA20); also elsewhere on the board
CPU_A20M#: U61.134 (CPUA20M#); also elsewhere on the board
CPU_A21: U61.103 (CPUA21); also elsewhere on the board
CPU_A22: U61.106 (CPUA22); also elsewhere on the board
CPU_A23: U61.107 (CPUA23); also elsewhere on the board
CPU_A24: U61.108 (CPUA24); also elsewhere on the board
CPU_A25: U61.109 (CPUA25); also elsewhere on the board
CPU_A31: U61.110 (CPUA31); also elsewhere on the board
CPU_ADS#: U61.112 (CPUADS#); also elsewhere on the board
CPU_AHOLD: U61.118 (CPUAHOLD); also elsewhere on the board
CPU_BE0#: U61.121 (CPUBE0#); also elsewhere on the board
CPU_BE1#: U61.122 (CPUBE1#); also elsewhere on the board
CPU_BE2#: U61.123 (CPUBE2#); also elsewhere on the board
CPU_BE3#: U61.124 (CPUBE3#); also elsewhere on the board
CPU_BLAST#: U61.113 (CPUBLAST#); also elsewhere on the board
CPU_BRDY#: U61.114 (CPUBRDY#); also elsewhere on the board
CPU_D0: U61.145 (D0); also elsewhere on the board
CPU_D1: U61.146 (D1); also elsewhere on the board
CPU_D2: U61.147 (D2); also elsewhere on the board
CPU_D3: U61.148 (D3); also elsewhere on the board
CPU_D4: U61.149 (D4); also elsewhere on the board
CPU_D5: U61.150 (D5); also elsewhere on the board
CPU_D6: U61.151 (D6); also elsewhere on the board
CPU_D7: U61.152 (D7); also elsewhere on the board
CPU_D8: U61.153 (D8); also elsewhere on the board
CPU_D9: U61.154 (D9); also elsewhere on the board
CPU_D10: U61.155 (D10); also elsewhere on the board
CPU_D11: U61.158 (D11); also elsewhere on the board
CPU_D12: U61.159 (D12); also elsewhere on the board
CPU_D13: U61.160 (D13); also elsewhere on the board
CPU_D14: U61.161 (D14); also elsewhere on the board
CPU_D15: U61.162 (D15); also elsewhere on the board
CPU_D16: U61.163 (D16); also elsewhere on the board
CPU_D17: U61.164 (D17); also elsewhere on the board
CPU_D18: U61.165 (D18); also elsewhere on the board
CPU_D19: U61.166 (D19); also elsewhere on the board
CPU_D20: U61.167 (D20); also elsewhere on the board
CPU_D21: U61.168 (D21); also elsewhere on the board
CPU_D22: U61.169 (D22); also elsewhere on the board
CPU_D23: U61.170 (D23); also elsewhere on the board
CPU_D24: U61.171 (D24); also elsewhere on the board
CPU_D25: U61.172 (D25); also elsewhere on the board
CPU_D26: U61.173 (D26); also elsewhere on the board
CPU_D27: U61.174 (D27); also elsewhere on the board
CPU_D28: U61.175 (D28); also elsewhere on the board
CPU_D29: U61.176 (D29); also elsewhere on the board
CPU_D30: U61.177 (D30); also elsewhere on the board
CPU_D31: U61.178 (D31); also elsewhere on the board
CPU_DC#: U61.132 (CPUDC#); also elsewhere on the board
CPU_EADS#: U61.133 (CPUEADS#); also elsewhere on the board
CPU_FLUSH#: U61.136 (CPUFLUSH#); also elsewhere on the board
CPU_HLDA: U61.119 (CPUHLDA); also elsewhere on the board
CPU_HOLD: U61.117 (CPUHOLD); also elsewhere on the board
CPU_INTR: U61.137 (CPUINTR); also elsewhere on the board
CPU_KEN#: U61.116 (CPUKEN#); also elsewhere on the board
CPU_LDEV#: U61.111 (CPULDEV#); also elsewhere on the board
CPU_MIO#: U61.131 (CPUMIO#); also elsewhere on the board
CPU_NMI: U61.138 (CPUNMI); also elsewhere on the board
CPU_RDY#: U61.115 (CPURDY#); also elsewhere on the board
CPU_RESET: U61.135 (CPURESET); also elsewhere on the board
CPU_SMI#: U61.141 (CPUSMI#); also elsewhere on the board
CPU_SMIACT#: U61.140 (CPUSMIACT#); also elsewhere on the board
CPU_SRESET: U61.139 (CPUSRESET#); also elsewhere on the board
CPU_STPCLK#: U61.144 (CPUSTPCLK#); also elsewhere on the board
CPU_WR#: U61.120 (CPUWR#); also elsewhere on the board
Chipset_2XCPU_CLK: U61.105 (CPU2XCLK); also elsewhere on the board
Chipset_32KHz: U61.73 (32KHz); also elsewhere on the board
Chipset_BIOS_CE#: U61.20 (BIOS_CE#); also elsewhere on the board
Chipset_CLK: U61.53 (CLOCK_IN); also elsewhere on the board
Chipset_CPU_CLK: R251.1, U61.125 (CPUCLK); also elsewhere on the board
Chipset_CPU_CLK_Sense: U61.129 (CPUCLKSENS); also elsewhere on the board
Chipset_FDC_TC: U61.22 (FDCTC); also elsewhere on the board
Chipset_SA16: U61.2 (SA16); also elsewhere on the board
Chipset_Sound: U61.54 (SPKR); also elsewhere on the board
Enable_IRDA_Buf: U7.15 (B7); also elsewhere on the board
FCS_IOCHRDY: R323.2, U61.23 (IOCHRDY); also elsewhere on the board
FCS_RESET: U58.4; also elsewhere on the board
GND: C8.2, C35.1, C69.2, C70.1, C73.1 (+), C75.2 (-), C76.2, C77.1 (+), C79.2, C80.2, C81.2 (-), C82.2, C250.1, C251.1, C252.2, C253.2, D23.2 (A), J4.2, R49.2, R57.2, R402.2, R404.2, R405.2, R406.2, U7.12 (GND), U7.13 (GND), U7.23 (G#), U19.4 (GND), U19.5, U19.7, U58.3 (GND), U61.11 (GND), U61.26 (GND), U61.34 (GND), U61.52 (GND), U61.82 (GND), U61.104 (GND), U61.128 (GND), U61.156 (GND), U61.179 (GND), U61.190 (GND), U61.208 (GND); also elsewhere on the board
IOCS16#: U61.28 (IOCS16#); also elsewhere on the board
IOR#: R326.2; also elsewhere on the board
IOW#: R318.1; also elsewhere on the board
KB_RESET#: U61.70 (KBRESET#); also elsewhere on the board
KB_SCLK#: U7.8 (A5); also elsewhere on the board
KB_SCLK_shift: U7.17 (B5); also elsewhere on the board
KB_SPKDN: U61.65 (KBSPKDN); also elsewhere on the board
KB_SRDY#: U7.7 (A4); also elsewhere on the board
KB_SRDY#_shift: U7.18 (B4); also elsewhere on the board
LA17: U61.3 (LA17); also elsewhere on the board
LA18: U61.4 (LA18); also elsewhere on the board
LA19: U61.5 (LA19); also elsewhere on the board
LA20: U61.6 (LA20); also elsewhere on the board
LA21: U61.7 (LA21); also elsewhere on the board
LA22: U61.8 (LA22); also elsewhere on the board
LA23: U61.9 (LA23); also elsewhere on the board
MEMCS16#: U61.27 (MEMCS16#); also elsewhere on the board
MEMR#: R322.1; also elsewhere on the board
MEMW#: R324.1; also elsewhere on the board
MIC_J17: J4.1; also elsewhere on the board
unnamed: D21.3 (A), R31.1
unnamed: D21.1 (A), D23.1 (K), R308.1
unnamed: D58.1 (K), R308.2
unnamed: R251.2, U61.127 (CPUCLK33)
unnamed: R326.1, U61.29 (IOR#)
unnamed: R318.2, U61.30 (IOW#)
unnamed: R322.2, U61.18 (MEMR#)
unnamed: R324.2, U61.19 (MEMW#)
unnamed: C79.1, R116.1, U61.66 (PS/RCLR#)
unnamed: R96.2, U19.2, U61.72 (PWRGD)
unnamed: R49.1, U7.6 (A3), U61.58 (PWRGD_P13)
unnamed: R346.2, U61.199 (RAMA0)
unnamed: R338.2, U61.198 (RAMA1)
unnamed: R342.2, U61.197 (RAMA2)
unnamed: R337.2, U61.195 (RAMA3)
unnamed: R334.2, U61.194 (RAMA4)
unnamed: R333.2, U61.193 (RAMA5)
unnamed: R343.2, U61.192 (RAMA6)
unnamed: R352.2, U61.191 (RAMA7)
unnamed: R347.2, U61.189 (RAMA8)
unnamed: R329.2, U61.188 (RAMA9)
unnamed: R345.2, U61.187 (RAMA10)
unnamed: R335.2, U61.186 (RAMA11)
unnamed: U58.2, U61.55 (RESET)
unnamed: C251.2, U61.68 (RTCOSCI), X3.1
unnamed: C250.2, U61.67 (RTCOSCO), X3.4
unnamed: J14.1, U61.57 (TP1)
unnamed: R246.2, U61.81 (UNKNOWN3)
unnamed: R249.2, U61.79 (UNKNOWN4)
PCMCIA_BALE: U61.33 (PCMCIA_BALE); also elsewhere on the board
PCMCIA_CLK: U61.25 (PCMCIA_CLK); also elsewhere on the board
PCMCIA_CS: U61.56 (PCMCIA_CS); also elsewhere on the board
PCMCIA_REFRESH: U61.10 (REFRESH#); also elsewhere on the board
PCMCIA_SBHE#: U61.14 (SBHE#); also elsewhere on the board
PCMCIA_ZEROWS#: U61.24 (ZEROWS#); also elsewhere on the board
PNET1: C69.1, C73.2 (-), C75.1 (+), C77.2 (-), C252.1, C253.1, R96.1, R246.1, R249.1, R400.2, R401.2, R403.2, U7.1 (VCCA), U7.2 (DIR), U19.1, U61.1 (VCC), U61.94 (VCC), U61.126 (VCC), U61.130 (VCC), U61.157 (VCC), U61.185 (VCC), U61.196 (VCC); also elsewhere on the board
PNET5: C35.2, U7.24 (VCCB); also elsewhere on the board
PNET7: C76.1, C81.1 (+), R323.1, U58.5 (VCC), U61.15 (VCCIO), U61.43 (VCCIO); also elsewhere on the board
PWRGD: U7.9 (A6), U19.6; also elsewhere on the board
PWRGD_shift: U7.16 (B6); also elsewhere on the board
Pluto_EN_IRDA: U7.10 (A7); also elsewhere on the board
RAM_A0: R346.1, R400.1, R404.1; also elsewhere on the board
RAM_A1: R338.1, R403.1, R406.1; also elsewhere on the board
RAM_A2: R342.1, R401.1, R402.1; also elsewhere on the board
RAM_A3: R337.1, R405.1; also elsewhere on the board
RAM_A4: R334.1; also elsewhere on the board
RAM_A5: R333.1; also elsewhere on the board
RAM_A6: R343.1; also elsewhere on the board
RAM_A7: R352.1; also elsewhere on the board
RAM_A8: R347.1; also elsewhere on the board
RAM_A9: R329.1; also elsewhere on the board
RAM_A10: R345.1; also elsewhere on the board
RAM_A11: R335.1; also elsewhere on the board
RTCBAT: C70.2, C80.1, C82.1, D21.2 (K), R116.2, R248.2, U19.8 (VCC), U61.69 (RTCBAT); also elsewhere on the board
SA0: U7.11 (A8), U61.12 (SA0); also elsewhere on the board
SA1: U61.13 (SA1); also elsewhere on the board
SD0: U61.35 (SD0); also elsewhere on the board
SD1: U61.36 (SD1); also elsewhere on the board
SD2: U61.37 (SD2); also elsewhere on the board
SD3: U61.38 (SD3); also elsewhere on the board
SD4: U61.39 (SD4); also elsewhere on the board
SD5: U61.40 (SD5); also elsewhere on the board
SD6: U61.41 (SD6); also elsewhere on the board
SD7: U61.42 (SD7); also elsewhere on the board
SD8: U61.44 (SD8); also elsewhere on the board
SD9: U61.45 (SD9); also elsewhere on the board
SD10: U61.46 (SD10); also elsewhere on the board
SD11: U61.47 (SD11); also elsewhere on the board
SD12: U61.48 (SD12); also elsewhere on the board
SD13: U61.49 (SD13); also elsewhere on the board
SD14: U61.50 (SD14); also elsewhere on the board
SD15: U61.51 (SD15); also elsewhere on the board
U61_RAM_LCASL#: U61.182 (LCASL#); also elsewhere on the board
U61_RAM_LCASU#: U61.184 (LCASU#); also elsewhere on the board
U61_RAM_RAMWE#: U61.180 (RAMWE#); also elsewhere on the board
U61_RAM_RAS0: U61.203 (RAS0); also elsewhere on the board
U61_RAM_RAS2: U61.201 (RAS2); also elsewhere on the board
U61_RAM_RAS3: U61.200 (RAS3); also elsewhere on the board
U61_RAM_UCASL#: U61.181 (UCASL#); also elsewhere on the board
U61_RAM_UCASU#: U61.183 (UCASU#); also elsewhere on the board
U61_RTCBAT_470K: R248.1, U61.71 (RTCBAT_Sense); also elsewhere on the board
U71_OR1_IN2: U7.19 (B3); also elsewhere on the board
UNKNOWN1: U7.4 (A1), U61.60 (UNKNOWN1)
UNKNOWN2: U7.5 (A2), U61.59 (UNKNOWN2)
VCC: D58.2 (A); also elsewhere on the board
YMF_SA0_A0: U7.14 (B8); also elsewhere on the board
YMF_VSS_Res: U61.62 (PCMCIA_RELATED); also elsewhere on the board

Notes on the sheet:
CPU_DATA_BUS
Device_Data_BUS
Device_Address_BUS
RAM_ADDRESS_BUS

Schematic: ASIC.kicad_sch, PC110

Parts:
C64, C71, C78, C110, C111, C125: 1nF; C_0402_1005Metric
C66, C130, C140, C277: 1uF; C_0603_1608Metric
C72, C117, C121, C127, C280: 100nF; C_0402_1005Metric
C74, C109: 180nF; C_0402_1005Metric
C108, C123: 150nF; C_0402_1005Metric
C113, C255: 120nF; C_0402_1005Metric
D26, D27, D28, D29: 3D
D32: K; SOT-416L
D33: N; SOT-416
Q14, Q18, Q38: 8C; SOT-416
Q16: IS6; TSOT-23
Q19: 8B; SOT-416
Q43, Q44: 8B; SOT-523
R104, R114, R393: 47k; R_0402_1005Metric
R119, R182, R186, R215, R216: 470k; R_0402_1005Metric
R129: 133k; R_0402_1005Metric
R149, R257: 33; R_0402_1005Metric
R180: 180k; R_0402_1005Metric
R185, R304: 4.7k; R_0402_1005Metric
R382: 50k; R_0402_1005Metric
R383: 33k; R_0402_1005Metric
R392, R398, R399: 22k; R_0402_1005Metric
R409: 2.2k; R_0402_1005Metric
R410: 20k; R_0402_1005Metric
R412: 7.5k; R_0402_1005Metric
RA1: 47k; R-array
SW2: LidSwitch
U9: E4; SOT-353
U21: Bowman
U35: Pluto
U37: E8; SOT-353
U38: 7W14; sso-8
U39: 7W00; sso-8
U40: SN74LS74a; TSSOP-14_4.4x5mm_P0.65mm
U45: SN74LS123A; TSSOP-16_4.4x5mm_P0.65mm

Connections:
AEN: U21.114 (AEN), U35.6 (AEN); also elsewhere on the board
BIOS_SA17: U35.54 (BIOS_SA17); also elsewhere on the board
Bowman1: U21.45 (Chipset_IO1); also elsewhere on the board
Bowman2: U21.140 (Chipset_IO2); also elsewhere on the board
Bowman3: R149.2; also elsewhere on the board
Bowman4: U21.52 (Chipset_IO4); also elsewhere on the board
Bowman5: U21.130 (Chipset_IO5); also elsewhere on the board
Bowman_Audio_Vol_Dn: U21.128 (VolDN); also elsewhere on the board
Bowman_Audio_Vol_Up: U21.127 (VolUP); also elsewhere on the board
Bowman_CLK: U21.40 (24MHz); also elsewhere on the board
Bowman_ESS_DACK1#: U21.122 (ESS_DACK#); also elsewhere on the board
CF_CD1_Pluto: U35.27 (CF_CD1#); also elsewhere on the board
CF_CD2_Pluto: U35.26 (CF_CD2#); also elsewhere on the board
CPU_A2: U21.10 (CPUA2); also elsewhere on the board
CPU_A3: U21.11 (CPUA3); also elsewhere on the board
CPU_A4: U21.12 (CPUA4); also elsewhere on the board
CPU_A5: U21.13 (CPUA5); also elsewhere on the board
CPU_A6: U21.14 (CPUA6); also elsewhere on the board
CPU_A7: U21.15 (CPUA7); also elsewhere on the board
CPU_A8: U21.16 (CPUA8); also elsewhere on the board
CPU_A9: U21.17 (CPUA9); also elsewhere on the board
CPU_A10: U21.19 (CPUA10); also elsewhere on the board
CPU_A11: U21.20 (CPUA11); also elsewhere on the board
CPU_A12: U21.21 (CPUA12); also elsewhere on the board
CPU_A13: U21.22 (CPUA13); also elsewhere on the board
CPU_A14: U21.23 (CPUA14); also elsewhere on the board
CPU_A15: U21.24 (CPUA15); also elsewhere on the board
CPU_A16: U21.25 (CPUA16); also elsewhere on the board
CPU_A17: U21.26 (CPUA17); also elsewhere on the board
CPU_A18: U21.27 (CPUA18); also elsewhere on the board
CPU_A19: U21.29 (CPUA19); also elsewhere on the board
CPU_A20: U21.30 (CPUA20); also elsewhere on the board
CPU_A21: U21.31 (CPUA21); also elsewhere on the board
CPU_A22: U21.32 (CPUA22); also elsewhere on the board
CPU_A23: U21.33 (CPUA23); also elsewhere on the board
CPU_A24: U21.34 (CPUA24); also elsewhere on the board
CPU_A25: U21.35 (CPUA25); also elsewhere on the board
CPU_ADS#: U21.49 (CPU_ADS#); also elsewhere on the board
CPU_DC#: U21.41 (CPU_DC#); also elsewhere on the board
CPU_INTR: U21.133 (CPU_INTR); also elsewhere on the board
CPU_LDEV#: U21.43 (LDEV#); also elsewhere on the board
CPU_MIO#: U21.50 (CPU_MIO#); also elsewhere on the board
CPU_RDY#: U21.134 (CPU_RDY#); also elsewhere on the board
CPU_RESET: U21.46 (CPU_RESET); also elsewhere on the board
CPU_SMIACT#: U9.1; also elsewhere on the board
CPU_STPCLK#: U35.62 (CPU_STPCLK#); also elsewhere on the board
CPU_WR#: U21.42 (CPU_WR#); also elsewhere on the board
Chipset_32KHz: U21.51 (32kHz); also elsewhere on the board
Chipset_CPU_CLK: R257.2; also elsewhere on the board
EN_LCD_VAA: U35.83 (PSU_IO); also elsewhere on the board
EN_RS232: U35.77 (EN_RS232); also elsewhere on the board
ESS_IRQ1_Buf: U21.118 (ESS_IRQ1); also elsewhere on the board
ESS_IRQ2_Buf: U21.87 (IRQ2); also elsewhere on the board
FDC_DACK#: U21.120 (DACK#); also elsewhere on the board
FDC_DS3: U21.123 (DS3#); also elsewhere on the board
FDC_FDRQ: U21.115 (FDRQ); also elsewhere on the board
FDC_FINTR: U21.82 (FINTR); also elsewhere on the board
FDC_IOW: U35.58 (Pluto_IOW); also elsewhere on the board
FDC_MTR2#: U21.121 (PDACK#); also elsewhere on the board
FDC_MTR3#: U21.117 (PDRQ); also elsewhere on the board
FDC_UART1_EN: D32.1 (K), R180.2, U35.76 (Dev_OE); also elsewhere on the board
FDD_Bowman: U21.125 (FDD_IO); also elsewhere on the board
FDD_Pluto1: D28.2 (K); also elsewhere on the board
FDD_Pluto2: D26.2 (K); also elsewhere on the board
FDD_Pluto3: D29.2 (K); also elsewhere on the board
FDD_Pluto4: D27.2 (K); also elsewhere on the board
GND: C64.1 (+), C66.1, C71.1, C72.2 (-), C74.1, C78.1, C108.1 (+), C109.1 (+), C110.1 (+), C111.2, C113.1 (+), C117.1, C121.2, C123.2, C125.1, C127.1, C255.1, C277.1, C280.1, Q14.2 (E), Q18.2 (E), Q19.2 (E), Q38.2 (E), Q43.2 (E), Q44.2 (E), R186.2, R383.1, U9.3 (GND), U21.8 (GND), U21.28 (GND), U21.44 (GND), U21.64 (GND), U21.80 (GND), U21.100 (GND), U21.116 (GND), U21.136 (GND), U35.4 (GND), U35.13 (GND), U35.37 (GND), U35.63 (GND), U35.87 (GND), U37.3 (GND), U38.4 (GND), U39.4 (GND), U40.7 (GND), U45.8 (GND), U45.9 (A); also elsewhere on the board
IOR#: U21.112 (IOR#), U35.86 (IOR#); also elsewhere on the board
IOW#: U21.113 (IOW#), U35.89 (IOW#); also elsewhere on the board
IRQ3: U21.85 (IRQ3); also elsewhere on the board
IRQ4: U21.84 (IRQ4); also elsewhere on the board
IRQ5: U21.83 (IRQ5); also elsewhere on the board
IRQ7: U21.81 (IRQ7); also elsewhere on the board
IRQ9: U21.79 (IRQ9); also elsewhere on the board
IRQ10: U21.78 (IRQ10); also elsewhere on the board
IRQ11: U21.77 (IRQ11); also elsewhere on the board
IRQ14: U21.75 (IRQ14); also elsewhere on the board
IRQ15: U21.74 (IRQ15); also elsewhere on the board
KBCCS#: U35.60 (KB_CCS); also elsewhere on the board
KB_CNTR#: U35.61 (KB_CNTR#); also elsewhere on the board
KB_IRQ1: U21.86 (KB_IRQ1); also elsewhere on the board
KB_IRQ12: U21.76 (IRQ12); also elsewhere on the board
KB_RESET#: U21.48 (KB_RESET#), U35.66 (KB_RESET#), U40.4 (~S), U40.10 (~S), U45.3 (Clr); also elsewhere on the board
KB_SCRLED#: U21.53 (KB_SCRLED#); also elsewhere on the board
KB_SPKDN: U35.43 (KB_SPKDN); also elsewhere on the board
KB_SPKUP: U35.44 (KB_SPKUP); also elsewhere on the board
LCD_NC_L11: U35.5 (LCD_IO); also elsewhere on the board
LCD_STNDBY#: R393.2, U35.93 (LCD_STNDBY); also elsewhere on the board
M38_P14_Buf: U21.107 (M38_IO9); also elsewhere on the board
M38_P15_Buf: U21.106 (M38_IO8); also elsewhere on the board
M38_P41: U21.111 (M38_IO11); also elsewhere on the board
M38_P43: U21.110 (M38_IO10); also elsewhere on the board
MEMCS16#: U21.119 (MEMCS16#); also elsewhere on the board
Modem_VSDA#: U35.75 (NM192_VDSA#); also elsewhere on the board
unnamed: D32.2 (A), R129.1
unnamed: D32.3 (common), Q18.1 (B), R180.1
unnamed: D33.3, R114.2
unnamed: Q14.1 (B), R114.1
unnamed: Q16.1 (B), R185.2
unnamed: Q18.3 (C), R185.1
unnamed: Q19.1 (B), R399.1
unnamed: Q19.3 (C), R410.2
unnamed: C277.2, Q38.1 (B), R382.2
unnamed: Q38.3 (C), R216.2, U35.45 (FF_1CLK), U38.1
unnamed: Q43.1 (B), R392.1
unnamed: Q43.3 (C), R412.2
unnamed: Q44.1 (B), R398.1
unnamed: Q44.3 (C), R409.2
unnamed: D26.1 (A), D26.3 (A), RA1.1 (R1.1), U35.69 (FDD_IO2)
unnamed: D28.1 (A), D28.3 (A), RA1.2 (R2.1), U35.68 (FDD_IO1)
unnamed: D27.1 (A), D27.3 (A), RA1.3 (R3.1), U35.71 (FDD_IO4)
unnamed: D29.1 (A), D29.3 (A), RA1.4 (R4.1), U35.70 (FDD_IO3)
unnamed: R382.1, R383.2, SW2.2 (B)
unnamed: R257.1, U21.38 (CPUCLK)
unnamed: R149.1, U21.39 (Chipset_IO3)
unnamed: R104.1, U21.138 (PSU_IO2)
unnamed: U9.4, U21.141 (PWRGD_IN)
unnamed: R186.1, U35.2 (FF_2D), U40.12 (D)
unnamed: U35.90 (FF_2Q#), U40.1 (~R), U45.12 (~Q)
unnamed: R304.1, U35.74 (PNET7_SENSE)
unnamed: R398.2, U35.55 (Pluto_55)
unnamed: R392.2, U35.56 (Pluto_56)
unnamed: R399.2, U35.57 (Pluto_57)
unnamed: U35.23 (SA13), U37.4
unnamed: U9.2, U38.5
unnamed: U38.7, U39.2, U40.3 (C)
unnamed: C125.2, U39.1, U40.6 (~Q)
unnamed: U40.8 (~Q), U45.11 (Clr)
unnamed: U35.46 (FF_1A), U35.78 (FF_1A), U45.1 (A)
unnamed: C130.2, U45.14 (Cext)
unnamed: D33.2, U45.13 (Q)
unnamed: C130.1, R182.2, U45.15 (RCext)
unnamed: U39.7, U45.10 (B)
unnamed: D33.1, U45.5 (Q)
unnamed: C140.1, R215.1, U45.7 (RCext)
OKI_CE#: U21.142 (ROMCE#); also elsewhere on the board
OKI_SA12: U21.9 (ROMA12); also elsewhere on the board
OKI_SA13: U21.7 (ROMA13); also elsewhere on the board
OKI_SA14: U21.6 (ROMA14); also elsewhere on the board
OKI_SA15: U21.5 (ROMA15); also elsewhere on the board
OKI_SA16: U21.4 (ROMA16); also elsewhere on the board
OKI_SA17: U21.3 (ROMA17); also elsewhere on the board
OKI_SA18: U21.2 (ROMA18); also elsewhere on the board
OKI_SA19: U21.143 (ROMA19); also elsewhere on the board
PNET1: C64.2 (-), C71.2, C72.1 (+), C74.2, C78.2, C108.2 (-), C109.2 (-), C110.2 (-), C111.1, C113.2 (-), C117.2, C121.1, C123.1, C127.2, C140.2, C255.2, C280.2, R182.1, R215.2, R216.1, R393.1, SW2.1 (A), U9.5 (VCC), U21.1 (VCC), U21.18 (VCC), U21.36 (VCC), U21.37 (VCC), U21.54 (VCC), U21.72 (VCC), U21.73 (VCC), U21.90 (VCC), U21.108 (VCC), U21.109 (VCC), U21.126 (VCC), U21.144 (VCC), U35.7 (VCC), U35.14 (VCC), U35.38 (VCC), U35.64 (VCC), U35.88 (VCC), U35.95 (VCC), U35.97 (VCC), U37.5 (VCC), U38.8 (VCC), U39.8 (VCC), U40.2 (D), U40.13 (~R), U40.14 (VCC), U45.2 (B), U45.6 (Cext), U45.16 (VCC); also elsewhere on the board
PNET2: U21.99 (VCC2); also elsewhere on the board
PNET5: Q16.2 (E); also elsewhere on the board
PNET7: R304.2, RA1.5 (R4.2), RA1.6 (R3.2), RA1.7 (R2.2), RA1.8 (R1.2); also elsewhere on the board
PS2_L1_Pluto: U35.30 (PS2_IO); also elsewhere on the board
PWRGD: U21.47 (PWRGD), U35.67 (PWRGD), U38.3; also elsewhere on the board
Pluto_50: U35.50 (PWR_ON_SENSE); also elsewhere on the board
Pluto_51: U21.129 (Pluto_IO), U35.51 (Bowman_IO1)
Pluto_52: U35.52 (Bowman_IO2); also elsewhere on the board
Pluto_72: U35.72 (FF_1Q); also elsewhere on the board
Pluto_73: U35.73 (FF_2Q); also elsewhere on the board
Pluto_BIOS_WR_EN: U35.53 (BIOS_WR_EN); also elsewhere on the board
Pluto_CLK: U35.65 (CLK); also elsewhere on the board
Pluto_Dock_IO1: U35.28 (Dock_Detect1); also elsewhere on the board
Pluto_Dock_IO2: U35.29 (Dock_Detect2); also elsewhere on the board
Pluto_EN_IRDA: U35.48 (IRDA_EN); also elsewhere on the board
Pluto_ESS_AEN: U35.79 (FDC_O); also elsewhere on the board
Pluto_IRDA_OUT: U35.81 (IRDA_O); also elsewhere on the board
Pluto_Switched_PNET5: Q16.3 (C), R129.2; also elsewhere on the board
R73_2: C66.2, R104.2; also elsewhere on the board
R412_1: R409.1, R410.1, R412.1; also elsewhere on the board
RAM_ID0: U35.31 (RAM_ID0); also elsewhere on the board
RAM_ID1: U35.32 (RAM_ID1); also elsewhere on the board
RTCBAT: R119.2; also elsewhere on the board
SA0: U21.55 (SA0), U35.8 (SA0); also elsewhere on the board
SA1: U21.56 (SA1), U35.9 (SA1); also elsewhere on the board
SA2: U21.57 (SA2), U35.10 (SA2); also elsewhere on the board
SA3: U21.58 (SA3), U35.11 (SA3); also elsewhere on the board
SA4: U21.59 (SA4), U35.12 (SA4); also elsewhere on the board
SA5: U21.60 (SA5), U35.15 (SA5); also elsewhere on the board
SA6: U21.61 (SA6), U35.16 (SA6); also elsewhere on the board
SA7: U21.62 (SA7), U35.17 (SA7); also elsewhere on the board
SA8: U21.63 (SA8), U35.18 (SA8); also elsewhere on the board
SA9: U21.65 (SA9), U35.19 (SA9); also elsewhere on the board
SA10: U21.66 (SA10), U35.20 (SA10); also elsewhere on the board
SA11: U21.67 (SA11), U35.21 (SA11); also elsewhere on the board
SA12: U21.68 (SA12), U35.22 (SA12), U37.1; also elsewhere on the board
SA13: U21.69 (SA13), U37.2; also elsewhere on the board
SA14: U21.70 (SA14), U35.24 (SA14); also elsewhere on the board
SA15: U21.71 (SA15), U35.25 (SA15); also elsewhere on the board
SD0: U21.96 (SD0), U35.33 (SD0); also elsewhere on the board
SD1: U21.95 (SD1), U35.34 (SD1); also elsewhere on the board
SD2: U21.94 (SD2), U35.35 (SD2); also elsewhere on the board
SD3: U21.93 (SD3), U35.36 (SD3); also elsewhere on the board
SD4: U21.92 (SD4), U35.39 (SD4); also elsewhere on the board
SD5: U21.91 (SD5), U35.40 (SD5); also elsewhere on the board
SD6: U21.89 (SD6), U35.41 (SD6); also elsewhere on the board
SD7: U21.88 (SD7), U35.42 (SD7); also elsewhere on the board
U21_97: U21.97 (M38_IO1); also elsewhere on the board
U21_98: U21.98 (M38_IO2); also elsewhere on the board
U21_101: U21.101 (M38_IO3); also elsewhere on the board
U21_102: U21.102 (M38_IO4); also elsewhere on the board
U21_103: U21.103 (M38_IO5); also elsewhere on the board
U21_104: U21.104 (M38_IO6); also elsewhere on the board
U21_105: U21.105 (M38_IO7); also elsewhere on the board
U21_131: U21.131 (PSU_IO1); also elsewhere on the board
U21_139: U21.139 (M38_IO12); also elsewhere on the board
U30_D0: U35.1 (FF_D0); also elsewhere on the board
U53_2CLK: U35.3 (FF_2CLK), U40.11 (C); also elsewhere on the board
VGA_ADDHI: U21.124 (ADDHI); also elsewhere on the board
YMF_VSS_Res: Q14.3 (C), R119.1; also elsewhere on the board

Notes on the sheet:
OKI_Extra_Address
CPU_ADDRESS_BUS
Device_Data_BUS
Device_Address_BUS

Schematic: Keyboard.kicad_sch, PC110

Parts:
C128, C136: 150nF; C_0402_1005Metric
C135: 2.7uF; C_0805_2012Metric
C264: 56pF; C_0402_1005Metric
C267: DNP; C_0402_1005Metric
C268: 56pf; C_0402_1005Metric
C274, C275: 100nF; C_0402_1005Metric
C281, C283: 39pF; C_0402_1005Metric
D35: 3D
J16: Flat-20
J17: Flat-8
J19: Flat-18
Q8: 6D; 3D
R45, R59, R201, R205, R372: 100k; R_0402_1005Metric
R196, R197, R200, R204, R206: 47k; R_0402_1005Metric
R198, R203: 10k; R_0402_1005Metric
R199, R202: DNP; R_0402_1005Metric; not fitted
U67: M38813M4; QFN64
U69: SN74LVC2G32; SSOP-8_2.95x2.8mm_P0.65mm
U72: HD151015; SSOP-24_5.3x8.2mm_P0.65mm
U73: SN74LVT244B; TSSOP-20_4.4x6.5mm_P0.65mm
U75: D17137AGT; SSOP-28
X5: 4.00; XTAL-5
X6: 8.00; XTAL-4

Connections:
/Keyboard and Trackpoint/D171_GPCLK: R198.1, U67.20 (P41/INT0), U75.22 (P0D3/TM0OUT#), U75.23 (P0D2/SI)
/Keyboard and Trackpoint/D171_GPDATA: R203.1, U67.21 (P40/INT4), U75.24 (P0D1/SO), U75.25 (P0D0/SCK#)
/Keyboard and Trackpoint/D171_P0A0: J19.6, U75.13 (P0A0)
/Keyboard and Trackpoint/D171_P0A1: J19.5, U75.12 (P0A1)
/Keyboard and Trackpoint/D171_P0A2: J19.4, U75.11 (P0A2)
/Keyboard and Trackpoint/D171_P0A3: J19.3, U75.10 (P0A3)
/Keyboard and Trackpoint/D171_P0B0: J19.15, U75.9 (P0B0)
/Keyboard and Trackpoint/D171_P0B1: J19.14, U75.8 (P0B1)
/Keyboard and Trackpoint/D171_P0B2: J19.13, U75.7 (P0B2)
/Keyboard and Trackpoint/D171_P0B3: J19.12, U75.6 (P0B3)
/Keyboard and Trackpoint/D171_P0C2: J19.2, R205.1, U75.3 (P0C2/ADC2)
/Keyboard and Trackpoint/D171_P0C3: J19.16, R201.1, U75.2 (P0C3/ADC3)
/Keyboard and Trackpoint/D171_P1A0: J19.18, U75.21 (P1A0)
/Keyboard and Trackpoint/D171_P1A1: J19.8, U75.20 (P1A1)
/Keyboard and Trackpoint/D171_P1A2: J19.17, U75.19 (P1A2)
/Keyboard and Trackpoint/D171_P1A3: J19.7, U75.18 (P1A3)
/Keyboard and Trackpoint/KB1_0: J17.8, U67.56 (P30/DA1)
/Keyboard and Trackpoint/KB1_1: J17.7, U67.55 (P31/DA2)
/Keyboard and Trackpoint/KB1_2: J17.1, U67.54 (P32/ONW#)
/Keyboard and Trackpoint/KB1_3: J17.6, U67.53 (P33)
/Keyboard and Trackpoint/KB1_4: J17.2, U67.52 (P34)
/Keyboard and Trackpoint/KB1_5: J17.5, U67.51 (P35/SYNC)
/Keyboard and Trackpoint/KB1_6: J17.3, U67.50 (P36/WR#)
/Keyboard and Trackpoint/KB1_7: J17.4, U67.49 (P37/RD#)
/Keyboard and Trackpoint/KB2_1: J16.18, U67.33 (P17/AD15)
/Keyboard and Trackpoint/KB2_2: J16.6, U67.34 (P16/AD14)
/Keyboard and Trackpoint/KB2_3: J16.17, U67.35 (P15/AD13)
/Keyboard and Trackpoint/KB2_4: J16.14, U67.36 (P14/AD12)
/Keyboard and Trackpoint/KB2_5: J16.16, U67.37 (P13/AD11)
/Keyboard and Trackpoint/KB2_6: J16.9, U67.38 (P12/AD10)
/Keyboard and Trackpoint/KB2_7: J16.5, U67.39 (P11/AD9)
/Keyboard and Trackpoint/KB2_8: J16.10, U67.40 (P10/AD8)
/Keyboard and Trackpoint/KB2_9: J16.8, U67.41 (P07/AD7)
/Keyboard and Trackpoint/KB2_10: J16.11, U67.42 (P06/AD6)
/Keyboard and Trackpoint/KB2_11: J16.7, U67.43 (P05/AD5)
/Keyboard and Trackpoint/KB2_12: J16.12, U67.44 (P04/AD4)
/Keyboard and Trackpoint/KB2_13: J16.13, U67.45 (P03/AD3)
/Keyboard and Trackpoint/KB2_14: J16.15, U67.46 (P02/AD2)
/Keyboard and Trackpoint/KB2_15: J16.20, U67.47 (P01/AD1)
/Keyboard and Trackpoint/KB2_16: J16.19, U67.48 (P00/AD0)
/Keyboard and Trackpoint/TRKPD_Lclick: J16.4, J19.10, R206.1, U75.4 (P0C1/ADC1)
/Keyboard and Trackpoint/TRKPD_Rclick: J16.3, J19.11, R196.1, U75.5 (P0C0/ADC0)
AEN: U69.6; also elsewhere on the board
Bowman_ESS_DACK1#: R372.2, U72.10 (A7); also elsewhere on the board
ESS_AEN: U72.16 (B6); also elsewhere on the board
ESS_DACK1#: U72.15 (B7); also elsewhere on the board
ESS_IRQ1: U73.13 (I1b); also elsewhere on the board
ESS_IRQ1_Buf: U73.7 (O1b); also elsewhere on the board
ESS_IRQ2: U73.15 (I2b); also elsewhere on the board
ESS_IRQ2_Buf: U73.5 (O2b); also elsewhere on the board
FCS_RESET: U72.11 (A8); also elsewhere on the board
FDC_DS3: U69.1; also elsewhere on the board
GND: C128.2, C135.2 (-), C136.2 (-), C264.1 (+), C267.1, C268.1 (+), C274.2, C275.2, C281.1 (+), C283.2 (-), J16.2, J19.9, R199.1, R202.1, U67.18 (CNVSS), U67.24 (VSS), U69.4 (GND), U72.12 (GND), U72.13 (GND), U72.23 (G#), U73.1 (OEa), U73.10 (GND), U73.19 (OEb), U75.14 (GND), X5.3, X6.3; also elsewhere on the board
IOR#: U67.5 (R#), U72.7 (A4); also elsewhere on the board
IOW#: U67.4 (W#), U72.8 (A5); also elsewhere on the board
KBCCS#: U67.6 (S#); also elsewhere on the board
KB_CAPLED#: U67.27 (P25/DB5), U72.4 (A1)
KB_CNTR#: U67.59 (PC60); also elsewhere on the board
KB_INIT1: U67.17 (P42/INT1); also elsewhere on the board
KB_INIT2: U67.16 (P43/INT2); also elsewhere on the board
KB_INIT3: U67.13 (P46/SCLK1); also elsewhere on the board
KB_INIT4: U67.12 (P47/SRDY1); also elsewhere on the board
KB_IRQ1: U67.15 (P44/RxD); also elsewhere on the board
KB_IRQ12: U67.14 (P45/TxD); also elsewhere on the board
KB_KBCSMI: U67.32 (P20/DB0), U73.12 (O3a)
KB_NUMLED#: U67.26 (P26/DB6), U72.3 (A0)
KB_PADLED#: U67.28 (P24/DB4), U72.5 (A2)
KB_RESET#: C267.2, U67.19 (RESET); also elsewhere on the board
KB_RXD: U67.11 (P50/SIN2), U73.9 (O0b)
KB_SCLK#: R45.1, U67.9 (P52/SCLK2); also elsewhere on the board
KB_SCLK_shift: Q8.3 (B); also elsewhere on the board
KB_SCRLED#: U67.25 (P27/DB7); also elsewhere on the board
KB_SPKDN: U67.30 (P22/DB2), U73.16 (O1a); also elsewhere on the board
KB_SPKUP: U67.29 (P23/DB3); also elsewhere on the board
KB_SRDY#: R59.1, U67.8 (P53/SRDY2); also elsewhere on the board
KB_Sound: U67.58 (P61); also elsewhere on the board
KB_TP139: U67.31 (P21/DB1), U73.14 (O2a)
KB_TXD: U67.10 (P51/SOUT2), U72.6 (A3)
M38_21: U72.21 (B1); also elsewhere on the board
M38_P14: U73.17 (I3b); also elsewhere on the board
M38_P14_Buf: U73.3 (O3b); also elsewhere on the board
M38_P15: U73.2 (I0a); also elsewhere on the board
M38_P15_Buf: U73.18 (O0a); also elsewhere on the board
M38_P22_R88: U73.8 (I3a); also elsewhere on the board
M38_P27_KB_SPKDN: U73.4 (I1a); also elsewhere on the board
M38_P35: U72.20 (B2); also elsewhere on the board
M38_P36: U72.22 (B0); also elsewhere on the board
M38_P44: U72.19 (B3); also elsewhere on the board
unnamed: C135.1 (+), D35.1 (A), D35.3 (A), R200.1, U75.16 (RESET#)
unnamed: C264.2 (-), U67.22 (Xin), X5.2
unnamed: C268.2 (-), U67.23 (Xout), X5.1
unnamed: C281.2 (-), U75.26 (Xout), X6.1
unnamed: C283.1 (+), U75.27 (Xin), X6.2
unnamed: U69.5, U69.7
unnamed: U69.3, U72.9 (A6)
unnamed: R199.2, R204.1, U75.15 (INT)
unnamed: R197.1, R202.2, U75.17 (P1B0)
PNET1: C128.1, C274.1, C275.1, R45.2, R59.2, R372.1, U67.57 (VCC), U69.8 (VCC), U72.1 (VCCA), U72.2 (DIR), U73.20 (VCC); also elsewhere on the board
PNET3: C136.1 (+), D35.2 (K), Q8.2 (C), R196.2, R197.2, R198.2, R200.2, R201.2, R203.2, R204.2, R205.2, R206.2, U75.1 (VADC), U75.28 (VDD)
PNET5: Q8.1 (E), U72.24 (VCCB); also elsewhere on the board
Pluto_ESS_AEN: U69.2; also elsewhere on the board
SA2: U67.7 (A0); also elsewhere on the board
SD0: U67.3 (DQ0); also elsewhere on the board
SD1: U67.2 (DQ1); also elsewhere on the board
SD2: U67.1 (DQ2); also elsewhere on the board
SD3: U67.64 (DQ3); also elsewhere on the board
SD4: U67.63 (DQ4); also elsewhere on the board
SD5: U67.62 (DQ5); also elsewhere on the board
SD6: U67.61 (DQ6); also elsewhere on the board
SD7: U67.60 (DQ7); also elsewhere on the board
U8_1A3_KB_TP139: U73.6 (I2a); also elsewhere on the board
U8_2A1_KB_RXD: U73.11 (I0b); also elsewhere on the board
YMF_RD#_Buf: U72.18 (B4); also elsewhere on the board
YMF_WR#_Buf: U72.17 (B5); also elsewhere on the board

Notes on the sheet:
Device_Address_BUS
Device_Data_BUS
