# Repository ahmadexp/Open-Source-PC110 (continued)

## KiCad design Mods/PC110-ITX/PC110.kicad_pcb (continued)

Schematic: Power.kicad_sch, PC110

Parts:
C27, C28: 18pF; C_0402_1005Metric
C29: 120nF; C_0402_1005Metric
C33, C65, C96, C216, C217, C219, C220, C223, C231, C234: 150nF; C_0402_1005Metric
C46, C190, C222, C224, C245: 10nF; C_0603_1608Metric
C47: 5.6uF; C_1206_3216Metric
C49: 2.2uF; C_0805_2012Metric
C51: 10uF; C_1206_3216Metric
C55, C58, C67, C139: 100nF; C_0402_1005Metric
C60, C63: 100nF; C_0603_1608Metric
C61: 180nF; C_0402_1005Metric
C98: 330pF; C_0402_1005Metric
C99, C228: 100pF; C_0402_1005Metric
C118: 2.7uF; C_0805_2012Metric
C137, C138, C179: 1nF; C_0402_1005Metric
C218, C221: 150nF; C_0603_1608Metric
C225, C226, C229: 1uF; C_0603_1608Metric
C233: 330nF; C_0603_1608Metric
D4, D14, D15, D17, D30, D31, D37, D42, D43, D45, D46, D49: N; SOT-416L
D6, D7: Q; 3D
D8, D11: DNP; 3D; not fitted
D10, D13: K; SOT-416L
D16, D18, D22: 3D
D38: 40; D_0603_1608Metric
D41, D47: 24; D_0603_1608Metric
D44: 83; D_0603_1608Metric
D48: A2; D_0603_1608Metric
D50: 26; D_0603_1608Metric
D51: C6; D_0603_1608Metric
D60: 3D; SOT-23
F1: 0.5A; Fuse_1206_3216Metric
J5: PSU_Connector
J6: BridgeBatt
J18: Flat-4
L4: 68uH; L_1210_3225Metric
L15: 1.5uH; L_0603_1608Metric
Q3: 582 B74; SOT-89-3
Q4, Q22: YQ; SOT-416L
Q5: HQ; SOT-416L
Q7, Q10, Q12, Q26, Q27, Q30: 8C; SOT-416
Q9: 8C; SOT-523
Q11, Q13: IS6; SOT-23
Q15, Q21, Q23: 8B; SOT-416
Q17: 6D; 3D
Q20: 7C; TSOT-23
Q28: 8LR; SOT-416
Q29: DNP; SOT-23
Q39, Q40: HQ; TSOT-23
Q41, Q42: CQ; TSOT-23
R38, R42, R86, R89, R98, R108, R283, R328, R330, R331, R336, R339, R351, R354, R355: 4.7k; R_0402_1005Metric
R39, R40, R85, R93, R95, R171, R240, R254, R280, R288, R356, R385, R397, R408, R411: 47k; R_0402_1005Metric
R41, R97, R109, R110, R232, R237, R281: 10k; R_0402_1005Metric
R43, R62, R63: 68k; R_0402_1005Metric
R44, R81, R87, R167, R209, R212, R214, R268, R349, R390, R407, R413: 100k; R_0402_1005Metric
R52, R207, R208, R211, R213: 120k; R_0402_1005Metric
R60, R266: 50k; R_0402_1005Metric
R68: 56; R_0805_2012Metric
R76, R386: 1k; R_0402_1005Metric
R80, R82, R83, R90, R128, R146, R152, R156, R235, R262, R278, R282, R287: 470k; R_0402_1005Metric
R84, R285: 0; R_0402_1005Metric
R99: 470; R_0402_1005Metric
R100: 220; R_0402_1005Metric
R107, R276: 33k; R_0402_1005Metric
R111: 100; R_0603_1608Metric
R210: 100K; R_0402_1005Metric
R239: 56; R_0603_1608Metric
R260: 133k; R_0402_1005Metric
R271: DNP; R_0402_1005Metric; not fitted
R277: 200k; R_0402_1005Metric
R286: 22k; R_0402_1005Metric
R313: 300; R_0805_2012Metric
R388: 3K; R_0402_1005Metric
SW1: Switch
U5: 74HC14; TSSOP-14_4.4x5mm_P0.65mm
U6: M38223E4HP; QFN-80
U13: 8C01; SOT-23-5
U14, U15, U52: EA; SOT-353
U20: 7W14; sso-8
U29: E2; SOT-353
U30: 74LVT74; TSSOP-14_4.4x5mm_P0.65mm
U32: V74; TSSOP-14_4.4x5mm_P0.65mm
U39: 7W00; sso-8
U43: Front LCD; LCD
U44: NJM2904M; soic-8-small
U50: 3T01; SOT-23-5
U53: 3F01; TSOP-5_1.65x3.05mm_P0.95mm
U54: SN74HC74; TSSOP-14_4.4x5mm_P0.65mm
U55: 3T01; TSOP-5_1.65x3.05mm_P0.95mm
X1: 245759; XTAL-2

Connections:
/Power/M38_COM0: U6.77 (COM0), U43.14
/Power/M38_COM1: U6.76 (COM1), U43.13
/Power/M38_COM2: U6.75 (COM2), U43.12
/Power/M38_COM3: U6.74 (COM3), U43.11
/Power/M38_P10_R413: Q42.3 (B), R411.2, R413.1
/Power/M38_P11_R167: Q39.3 (B), R167.1, R171.2
/Power/M38_P12_R407: Q41.3 (B), R407.2, R408.2
/Power/M38_P13_R390: Q40.3 (B), R385.1, R390.1
/Power/M38_SEG0: U6.70 (SEG0), U43.1
/Power/M38_SEG1: U6.69 (SEG1), U43.2
/Power/M38_SEG2: U6.68 (SEG2), U43.3
/Power/M38_SEG3: U6.67 (SEG3), U43.4
/Power/M38_SEG4: U6.66 (SEG4), U43.5
/Power/M38_SEG5: U6.65 (SEG5), U43.6
/Power/M38_SEG6: U6.64 (SEG6), U43.7
/Power/M38_SEG7: U6.63 (SEG7), U43.8
/Power/M38_SEG8: U6.62 (SEG8), U43.9
/Power/M38_SEG9: U6.61 (SEG9), U43.10
/Power/Touch_X+: J18.2, R207.2, R386.1
/Power/Touch_X-: J18.3, Q41.2 (C)
/Power/Touch_Y+: J18.1, R208.2, R388.1
/Power/Touch_Y-: J18.4, Q42.2 (C)
/Power/U32_R: Q12.3 (C), R81.2, U32.1 (~R), U32.13 (~R)
/Power/U54_Q: D11.2 (K), J5.25, R235.2, U54.5 (Q)
CMOS_BATT_Sense: R41.2, U6.6 (P62); also elsewhere on the board
D4_3: D4.3, J5.35
D11_2: D11.3 (A); also elsewhere on the board
D18_2_3: D37.1, D37.2, J5.21, R397.2
D28_1: C221.2 (-), D50.1 (K), J5.12; also elsewhere on the board
D46_1: D46.1, J5.39
Dock_PWR_IN-: J5.5, J5.36, J5.37; also elsewhere on the board
EN_LCD_VAA: R397.1; also elsewhere on the board
F65_ENAVEE: D37.3, J5.26, R237.1; also elsewhere on the board
GND: C27.2, C28.2, C33.2 (-), C47.2 (-), C49.1 (+), C51.2 (-), C55.1, C58.1, C61.2, C63.1, C96.1, C98.2, C99.1, C118.2 (-), C139.1, C179.2 (-), C190.2 (-), C216.2, C217.2, C218.2 (-), C219.2, C220.1, C221.1 (+), C222.1 (+), C223.1, C224.1 (+), C226.1 (+), C228.2 (-), C229.1 (+), C231.1, C233.2 (-), C234.1 (+), C245.1 (+), D41.2 (A), D47.2 (A), J5.7, J5.9, J5.24, J5.29, J5.32, J6.2, Q3.1 (GND), Q4.1 (E), Q7.2 (E), Q12.2 (E), Q15.2 (E), Q21.2 (E), Q22.1 (E), Q23.2 (E), Q26.2 (E), Q27.2 (E), Q28.2 (E), Q41.1 (E), Q42.1 (E), R60.1, R63.1, R80.1, R82.2, R83.2, R90.1, R98.2, R108.2, R209.2, R210.2, R211.2, R213.2, R271.1, R280.2, R408.1, R411.1, U5.7 (GND), U6.16 (P50), U6.30 (GND), U6.73 (GND), U13.3 (GND), U14.3 (GND), U15.3 (GND), U29.3 (GND), U30.7 (GND), U32.7 (GND), U44.4 (V-), U50.3 (GND), U52.3 (GND), U53.3 (GND), U54.7 (GND), U55.3 (GND); also elsewhere on the board
KB_RESET#: D16.1 (A), D16.3 (A), R109.2; also elsewhere on the board
KB_SPKUP: Q27.3 (C), R268.1; also elsewhere on the board
KB_SPKUP_DN: R262.1; also elsewhere on the board
LCD_VAA: C179.1 (+), C190.1 (+), L15.1 (+); also elsewhere on the board
M38_21: U6.55 (21); also elsewhere on the board
M38_P14: U6.42 (P14); also elsewhere on the board
M38_P15: U6.41 (P15); also elsewhere on the board
M38_P16_R86: R86.1; also elsewhere on the board
M38_P20: J5.19, U6.38 (P20)
M38_P21: J5.22, U6.37 (P21)
M38_P22_R88: R89.1; also elsewhere on the board
M38_P27_KB_SPKDN: U6.31 (P27); also elsewhere on the board
M38_P34: R356.1, U6.58 (P34); also elsewhere on the board
M38_P35: U6.57 (P35); also elsewhere on the board
M38_P36: U6.56 (P36); also elsewhere on the board
M38_P41: U6.23 (P41); also elsewhere on the board
M38_P43: U6.21 (P43); also elsewhere on the board
M38_P44: U6.20 (P44); also elsewhere on the board
M38_P46: R288.2, U6.18 (P46); also elsewhere on the board
M38_P52: J5.18, U6.14 (P52)
M38_P53: J5.23, U6.13 (P53)
M38_P60: J5.1, U6.8 (P60)
M38_P61: J5.2, U6.7 (P61)
M38_P63: J5.40, U6.5 (P63)
M38_P64: J5.34, U6.4 (P64)
M38_P65: C137.2, R214.2, U6.3 (P65), U44.1
M38_P66: C138.2, R212.2, U6.2 (P66), U44.7
M38_P67: R60.2, U6.1 (P67); also elsewhere on the board
M38_P71: D4.2, R44.2, U5.3, U6.26 (P71)
M38_RESET: C99.2, R81.1, R282.2, U6.25 (RESET), U30.4 (~S), U53.1 (OUT)
M38_VREF: C216.1, C223.2, J5.31, R41.1, U6.72 (VREF)
MN192_VSEN#: C226.2 (-), R277.2, U5.11; also elsewhere on the board
MN195_U1RD#: R128.2, U5.13; also elsewhere on the board
unnamed: C46.1 (+), Q3.3 (VO), R76.1
unnamed: C46.2 (-), Q4.2 (B), R76.2
unnamed: C47.1 (+), L4.1, Q5.3 (C)
unnamed: C49.2 (-), Q3.2 (VI), R68.2
unnamed: C60.1, C63.2
unnamed: C65.1 (+), C67.1 (+)
unnamed: C224.2 (-), D47.1 (K), R281.1, U55.2 (VDD)
unnamed: C225.1 (+), D45.3, D46.3, D49.3, Q30.1 (E), R276.2
unnamed: C29.2 (-), C225.2 (-), Q30.2 (C)
unnamed: C228.1 (+), Q30.3 (B), R282.1, U54.1 (~R)
unnamed: C229.2 (-), R235.1, U54.13 (~R)
unnamed: C233.1 (+), Q29.1 (K), U53.5 (CD)
unnamed: C234.2 (-), Q29.2 (K), R285.1, U53.2 (VDD)
unnamed: C245.2 (-), D22.2 (K), F1.1, Q5.1 (E)
unnamed: D7.3 (K), L4.2, Q4.3 (C)
unnamed: D10.2 (A), D13.1 (K)
unnamed: C58.2, D10.1 (K), U14.5 (VCC), U15.5 (VCC)
unnamed: D14.2, R93.1
unnamed: D15.2, R95.1
unnamed: D16.2 (K), U14.4
unnamed: D17.2, U39.3
unnamed: D17.3, R254.2
unnamed: D18.2 (K), U14.2, U15.4
unnamed: D22.1 (A), D22.3 (A), R313.2
unnamed: D38.2 (A), Q21.3 (C)
unnamed: D38.1 (K), R232.2
unnamed: D41.1 (K), R260.1, R266.2, R271.2, U50.2 (VDD)
unnamed: D42.1, D42.2, D43.1, D43.2, R287.1, U52.2
unnamed: D42.3, U5.4
unnamed: D43.3, U5.2
unnamed: D44.2 (A), D45.1
unnamed: D46.2, R286.1
unnamed: D45.2, D48.2 (A)
unnamed: D49.1, D50.2 (A)
unnamed: D49.2, D51.2 (A)
unnamed: J5.17, U54.2 (D), U54.6 (~Q)
unnamed: F1.2, J6.1
unnamed: L15.2 (-), Q20.3 (C), R239.1, R240.1
unnamed: Q5.2 (B), R111.1
unnamed: Q7.1 (B), R87.1
unnamed: C98.1, Q7.3 (C), R146.2, U30.13 (~R)
unnamed: Q9.1 (B), R107.1
unnamed: Q9.3 (C), R99.1
unnamed: D14.1, Q9.2 (E)
unnamed: Q10.1 (B), R97.1
unnamed: Q10.3 (C), R100.1
unnamed: D15.1, Q10.2 (E)
unnamed: Q11.1 (B), R93.2, R99.2
unnamed: Q12.1 (B), R85.2
unnamed: Q13.1 (B), R95.2, R100.2
unnamed: Q15.3 (C), R111.2
unnamed: Q17.3 (B), U6.39 (P17)
unnamed: Q20.1 (B), R232.1
unnamed: Q21.1 (B), Q23.1 (B), R237.2
unnamed: Q22.2 (B), Q23.3 (C), R240.2
unnamed: Q22.3 (C), R239.2
unnamed: Q26.1 (B), R254.1
unnamed: Q27.1 (B), R262.2
unnamed: Q28.1 (B), R260.2, U50.1 (OUT)
unnamed: Q39.2 (C), R388.2
unnamed: Q40.2 (C), R386.2
unnamed: R268.2, U52.4
unnamed: R277.1, R280.1, SW1.2 (B)
unnamed: R336.1, U6.52 (P02)
unnamed: R339.2, U6.51 (P03)
unnamed: R328.1, U6.50 (P04)
unnamed: R354.1, U6.49 (P05)
unnamed: R355.1, U6.48 (P06)
unnamed: R413.2, U6.46 (P10)
unnamed: R167.2, U6.45 (P11)
unnamed: R407.1, U6.44 (P12)
unnamed: R390.2, U6.43 (P13)
unnamed: R86.2, U6.40 (P16)
unnamed: R89.2, U6.36 (P22)
unnamed: R283.1, U6.35 (P23)
unnamed: R42.2, U6.24 (P40)
unnamed: R38.1, U6.19 (P45)
unnamed: R39.1, U6.15 (P51)
unnamed: D60.3, U6.9 (P57)
unnamed: R331.2, U6.54 (SEG00)
unnamed: R351.1, U6.53 (SEG01)
unnamed: R330.2, U6.47 (SEG07)
unnamed: R43.2, R63.2, U6.80 (VL1)
unnamed: R43.1, R62.1, U6.79 (VL2)
unnamed: R52.1, R62.2, U6.78 (VL3)
unnamed: C28.1, U6.28 (Xin), X1.1 (+)
unnamed: R40.1, U6.29 (Xout)
unnamed: C60.2, D8.3 (A), U13.5 (CD)
unnamed: R83.1, U13.1 (OUT), U15.2
unnamed: C55.2, D8.1 (A), D11.1 (A), R84.1, U13.2 (VDD)
unnamed: R146.1, U30.6 (~Q)
unnamed: U5.12, U30.11 (C)
unnamed: D17.1, U30.9 (Q), U32.11 (C)
unnamed: U29.1, U30.8 (~Q)
unnamed: D30.3, U32.5 (Q)
unnamed: U29.2, U32.6 (~Q)
unnamed: D31.3, U32.9 (Q)
unnamed: R207.1, R210.1, U44.3 (+)
unnamed: C137.1, R211.1, R214.1, U44.2 (-)
unnamed: R208.1, R209.1, U44.5 (+)
unnamed: C138.1, R212.1, R213.1, U44.6 (-)
unnamed: U5.10, U54.3 (C)
unnamed: U5.8, U54.11 (C)
unnamed: R286.2, U54.9 (Q)
unnamed: R278.1, U5.9, U55.1 (OUT)
unnamed: C27.1, R40.2, X1.2 (-)
PNET1: C65.2 (-), C219.1, D8.2 (K), D44.1 (K), J5.8, J5.33, Q13.2 (E), R84.2, R109.1, R110.2, R152.1, R156.1, R287.2, R349.2, U39.5, U52.5 (VCC); also elsewhere on the board
PNET2: Q11.3 (C), R107.2, R108.1, R354.2; also elsewhere on the board
PNET4: D6.2 (A), J5.3, J5.4, J5.38; also elsewhere on the board
PNET5: C33.1 (+), D48.1 (K), J5.10, J5.11, J5.30, Q11.2 (E), Q17.1 (E), R39.2; also elsewhere on the board
PNET7: Q13.3 (C), R97.2, R98.1, R313.1; also elsewhere on the board
PNET8: C118.1 (+), C139.2, Q17.2 (C), Q39.1 (E), Q40.1 (E), R171.1, R385.2, U44.8 (V+)
PSU_AUX_SW1: J5.28, R42.1, U5.1
PWRGD_shift: R87.2, U20.1; also elsewhere on the board
PWRGD_shift_buff: D14.3, D15.3, U6.27 (PWRGD), U20.7; also elsewhere on the board
Pluto_50: R276.1; also elsewhere on the board
Pluto_52: R85.1; also elsewhere on the board
Pluto_72: D30.1, D30.2, R156.2; also elsewhere on the board
Pluto_73: D31.1, D31.2, R152.2; also elsewhere on the board
Q43_2: C222.2 (-), D51.1 (K), J5.13, Q20.2 (E)
R73_2: J5.15; also elsewhere on the board
R284_2: C218.1 (+), J5.14, R266.1, R281.2
R412_1: J5.20; also elsewhere on the board
RESET: D18.1 (A), D18.3 (A), R110.1; also elsewhere on the board
RIOUT#: U39.6; also elsewhere on the board
U8_1A3_KB_TP139: R283.2; also elsewhere on the board
U8_2A1_KB_RXD: R38.2; also elsewhere on the board
U21_97: R330.1; also elsewhere on the board
U21_98: R355.2; also elsewhere on the board
U21_101: R328.2; also elsewhere on the board
U21_102: R339.1; also elsewhere on the board
U21_103: R336.2; also elsewhere on the board
U21_104: R351.2; also elsewhere on the board
U21_105: R331.1; also elsewhere on the board
U21_131: J5.27; also elsewhere on the board
U21_139: D60.1, D60.2, R349.1; also elsewhere on the board
U30_D0: R90.2, U30.2 (D); also elsewhere on the board
U53_2CLK: R82.1, U30.3 (C); also elsewhere on the board
U54_1PRE#: U29.4, U54.4 (~S)
U61_RTCBAT_470K: Q26.3 (C); also elsewhere on the board
U106_1CLK: R80.2, U6.11 (1CLK), U32.3 (C)
VCC: C29.1 (+), C61.1, C67.2 (-), C96.2, C217.1, C220.2, C231.2, D13.2 (A), J5.16, Q29.3 (A), R44.1, R52.2, R128.1, R278.2, R285.2, R288.1, R356.2, SW1.1 (A), U5.14 (VCC), U6.71 (VCC), U29.5 (VCC), U30.1 (~R), U30.10 (~S), U30.12 (D), U30.14 (VCC), U32.2 (D), U32.10 (~S), U32.12 (D), U32.14 (VCC), U54.10 (~S), U54.12 (D), U54.14 (VCC); also elsewhere on the board
YellowWire1_2: Q15.1 (B); also elsewhere on the board

Notes on the sheet:
YellowWire2_3
5v switched on via PWRGD
YellowWire2_1
10.5v
YellowWire1
U103_NAND_of_U53_1CLK_and_U53_1Q#

Schematic: PCMCIA.kicad_sch, PC110

Parts:
C87, C279: 120nF; C_0402_1005Metric
C114, C115, C116, C119, C122, C276: 100nF; C_0402_1005Metric
C124, C273: 150nF; C_0603_1608Metric
C126, C278: 150nF; C_0402_1005Metric
J10: PCMCIA
R115, R163, R164, R166, R168, R169, R170, R172, R174, R175, R176, R178, R179, R325, R384, R389, R391, R396: 10k; R_0402_1005Metric
R117, R165, R177, R312: 47k; R_0402_1005Metric
R126, R160, R162, R379: 470k; R_0402_1005Metric
R316: 1k; R_0402_1005Metric
R317: 33; R_0402_1005Metric
R363: 100k; R_0402_1005Metric
R387: DNP; R_0402_1005Metric
R394: DNP; R_0402_1005Metric; not fitted
U38: 7W14; sso-8
U70: TPS2201; TSSOP-30_6.1x9.7mm_P0.65mm
U74: LQFP208

Connections:
/PCMCIA/A5VDET: J10.19 (A5VDET_AGPI), U74.3 (A5VDET/AGPI)
/PCMCIA/ABVD1: J10.59 (ABVD1_STSCHG#), R163.2, U74.61 (ABVD1/STSCHG#)
/PCMCIA/ABVD2: J10.57 (ABVD2_SPKR#), R176.2, U74.59 (ABVD2/SPKR#)
/PCMCIA/ACA0: J10.58 (ACA0), U74.60 (ACA0)
/PCMCIA/ACA1: J10.56 (ACA1), U74.58 (ACA1)
/PCMCIA/ACA2: J10.54 (ACA2), U74.57 (ACA2)
/PCMCIA/ACA3: J10.52 (ACA3), U74.55 (ACA3)
/PCMCIA/ACA4: J10.50 (ACA4), U74.53 (ACA4)
/PCMCIA/ACA5: J10.48 (ACA5), U74.50 (ACA5)
/PCMCIA/ACA6: J10.46 (ACA6), U74.49 (ACA6)
/PCMCIA/ACA7: J10.44 (ACA7), U74.47 (ACA7)
/PCMCIA/ACA8: J10.24 (ACA8), U74.30 (ACA8)
/PCMCIA/ACA9: J10.22 (ACA9), U74.28 (ACA9)
/PCMCIA/ACA10: J10.16 (ACA10), U74.21 (ACA10)
/PCMCIA/ACA11: J10.20 (ACA11), U74.25 (ACA11)
/PCMCIA/ACA12: J10.42 (ACA12), U74.45 (ACA12)
/PCMCIA/ACA13: J10.26 (ACA13), U74.33 (ACA13)
/PCMCIA/ACA14: J10.28 (ACA14), U74.35 (ACA14)
/PCMCIA/ACA15: J10.40 (ACA15), U74.43 (ACA15)
/PCMCIA/ACA16: J10.38 (ACA16), U74.41 (ACA16)
/PCMCIA/ACA17: J10.25 (ACA17), U74.32 (ACA17)
/PCMCIA/ACA18: J10.27 (ACA18), U74.34 (ACA18)
/PCMCIA/ACA19: J10.29 (ACA19), U74.36 (ACA19)
/PCMCIA/ACA20: J10.31 (ACA20), U74.38 (ACA20)
/PCMCIA/ACA21: J10.33 (ACA21), U74.40 (ACA21)
/PCMCIA/ACA22: J10.39 (ACA22), U74.42 (ACA22)
/PCMCIA/ACA23: J10.41 (ACA23), U74.44 (ACA23)
/PCMCIA/ACA24: J10.43 (ACA24), U74.46 (ACA24)
/PCMCIA/ACA25: J10.45 (ACA25), U74.48 (ACA25)
/PCMCIA/ACD0: J10.60 (ACD0), U74.62 (ACD0)
/PCMCIA/ACD1: J10.62 (ACD1), U74.64 (ACD1)
/PCMCIA/ACD1#: J10.5 (ACD1#), R117.2, U74.10 (ACD1#)
/PCMCIA/ACD2: J10.64 (ACD2), U74.66 (ACD2)
/PCMCIA/ACD2#: J10.67 (ACD2#), R177.2, U74.69 (ACD2#)
/PCMCIA/ACD3: J10.4 (ACD3), U74.9 (ACD3)
/PCMCIA/ACD4: J10.6 (ACD4), U74.11 (ACD4)
/PCMCIA/ACD5: J10.8 (ACD5), U74.13 (ACD5)
/PCMCIA/ACD6: J10.10 (ACD6), U74.15 (ACD6)
/PCMCIA/ACD7: J10.12 (ACD7), U74.17 (ACD7)
/PCMCIA/ACD8: J10.61 (ACD8), U74.63 (ACD8)
/PCMCIA/ACD9: J10.63 (ACD9), U74.65 (ACD9)
/PCMCIA/ACD10: J10.65 (ACD10), U74.67 (ACD10)
/PCMCIA/ACD11: J10.7 (ACD11), U74.12 (ACD11)
/PCMCIA/ACD12: J10.9 (ACD12), U74.14 (ACD12)
/PCMCIA/ACD13: J10.11 (ACD13), U74.16 (ACD13)
/PCMCIA/ACD14: J10.13 (ACD14), U74.18 (ACD14)
/PCMCIA/ACD15: J10.15 (ACD15), U74.20 (ACD15)
/PCMCIA/ACE1#: J10.14 (ACE1#), U74.19 (ACE1#)
/PCMCIA/ACE2#: J10.17 (ACE2#), U74.22 (ACE2#)
/PCMCIA/ACIORD#: J10.21 (ACIORD#), U74.26 (ACIORD#)
/PCMCIA/ACIOWR#: J10.23 (ACIOWR#), U74.29 (ACIOWR#)
/PCMCIA/AINPACK#: J10.53 (AINPACK#), R179.2, U74.56 (AINPACK#)
/PCMCIA/AOE#: J10.18 (AOE#), U74.23 (AOE#)
/PCMCIA/ARDY: J10.32 (ARDY_BSY#), R174.2, U74.39 (ARDY/BSY#)
/PCMCIA/AREG#: J10.55 (AREG#), U74.8 (AREG#)
/PCMCIA/ARESET: J10.49 (ARESET), U74.51 (ARESET)
/PCMCIA/AVPP: C124.2 (-), J10.36 (AVPP), J10.37 (AVPP), U70.8 (AVPP)
/PCMCIA/AWAIT: J10.51 (AWAIT#), R164.2, U74.54 (AWAIT#)
/PCMCIA/AWE#: J10.30 (AWE#), U74.37 (AWE#)
/PCMCIA/AWP: J10.66 (AWP_IOIS16#), R168.2, U74.68 (AWP/IOIS16#)
/PCMCIA/B5VDET: J10.89 (B5VDET_BGPI), U74.6 (B5VDET/BGPI)
/PCMCIA/BBVD1: J10.129 (BBVD1_STSCHG#), R175.1, U74.124 (BBVD1/STSCHG#)
/PCMCIA/BBVD2: J10.127 (BBVD2_SPKR#), R170.2, U74.122 (BBVD2/SPKR#)
/PCMCIA/BCA0: J10.128 (BCA0), U74.123 (BCA0)
/PCMCIA/BCA1: J10.126 (BCA1), U74.121 (BCA1)
/PCMCIA/BCA2: J10.124 (BCA2), U74.120 (BCA2)
/PCMCIA/BCA3: J10.122 (BCA3), U74.118 (BCA3)
/PCMCIA/BCA4: J10.120 (BCA4), U74.115 (BCA4)
/PCMCIA/BCA5: J10.118 (BCA5), U74.113 (BCA5)
/PCMCIA/BCA6: J10.116 (BCA6), U74.112 (BCA6)
/PCMCIA/BCA7: J10.114 (BCA7), U74.109 (BCA7)
/PCMCIA/BCA8: J10.94 (BCA8), U74.93 (BCA8)
/PCMCIA/BCA9: J10.92 (BCA9), U74.91 (BCA9)
/PCMCIA/BCA10: J10.86 (BCA10), U74.85 (BCA10)
/PCMCIA/BCA11: J10.90 (BCA11), U74.89 (BCA11)
/PCMCIA/BCA12: J10.112 (BCA12), U74.107 (BCA12)
/PCMCIA/BCA13: J10.96 (BCA13), U74.95 (BCA13)
/PCMCIA/BCA14: J10.98 (BCA14), U74.97 (BCA14)
/PCMCIA/BCA15: J10.110 (BCA15), U74.105 (BCA15)
/PCMCIA/BCA16: J10.108 (BCA16), U74.103 (BCA16)
/PCMCIA/BCA17: J10.95 (BCA17), U74.94 (BCA17)
/PCMCIA/BCA18: J10.97 (BCA18), U74.96 (BCA18)
/PCMCIA/BCA19: J10.99 (BCA19), U74.98 (BCA19)
/PCMCIA/BCA20: J10.101 (BCA20), U74.100 (BCA20)
/PCMCIA/BCA21: J10.103 (BCA21), U74.102 (BCA21)
/PCMCIA/BCA22: J10.109 (BCA22), U74.104 (BCA22)
/PCMCIA/BCA23: J10.111 (BCA23), U74.106 (BCA23)
/PCMCIA/BCA24: J10.113 (BCA24), U74.108 (BCA24)
/PCMCIA/BCA25: J10.115 (BCA25), U74.110 (BCA25)
/PCMCIA/BCD0: J10.130 (BCD0), U74.125 (BCD0)
/PCMCIA/BCD1: J10.132 (BCD1), U74.127 (BCD1)
/PCMCIA/BCD1#: J10.75 (BCD1#), R312.2, U74.73 (BCD1#)
/PCMCIA/BCD2: J10.134 (BCD2), U74.129 (BCD2)
/PCMCIA/BCD2#: J10.137 (BCD2#), R165.1, U74.132 (BCD2#)
/PCMCIA/BCD3: J10.74 (BCD3), U74.72 (BCD3)
/PCMCIA/BCD4: J10.76 (BCD4), U74.74 (BCD4)
/PCMCIA/BCD5: J10.78 (BCD5), U74.76 (BCD5)
/PCMCIA/BCD6: J10.80 (BCD6), U74.78 (BCD6)
/PCMCIA/BCD7: J10.82 (BCD7), U74.81 (BCD7)
/PCMCIA/BCD8: J10.131 (BCD8), U74.126 (BCD8)
/PCMCIA/BCD9: J10.133 (BCD9), U74.128 (BCD9)
/PCMCIA/BCD10: J10.135 (BCD10), U74.130 (BCD10)
/PCMCIA/BCD11: J10.77 (BCD11), U74.75 (BCD11)
/PCMCIA/BCD12: J10.79 (BCD12), U74.77 (BCD12)
/PCMCIA/BCD13: J10.81 (BCD13), U74.80 (BCD13)
/PCMCIA/BCD14: J10.83 (BCD14), U74.82 (BCD14)
/PCMCIA/BCD15: J10.85 (BCD15), U74.84 (BCD15)
/PCMCIA/BCE1#: J10.84 (BCE1#), U74.83 (BCE1#)
/PCMCIA/BCE2#: J10.87 (BCE2#), U74.86 (BCE2#)
/PCMCIA/BCIORD#: J10.91 (BCIORD#), U74.90 (BCIORD#)
/PCMCIA/BCIOWR#: J10.93 (BCIOWR#), U74.92 (BCIOWR#)
/PCMCIA/BINPACK#: J10.123 (BINPACK#), R172.1, U74.119 (BINPACK#)
/PCMCIA/BOE#: J10.88 (BOE#), U74.87 (BOE#)
/PCMCIA/BRDY: J10.102 (BRDY_BSY#), R166.2, U74.101 (BRDY/BSY#)
/PCMCIA/BREG#: J10.125 (BREG#), U74.71 (BREG#)
/PCMCIA/BRESET: J10.119 (BRESET), U74.114 (BRESET)
/PCMCIA/BVPP: C273.1 (+), J10.106 (BVPP), J10.107 (BVPP), U70.23 (BVPP)
/PCMCIA/BWAIT: J10.121 (BWAIT#), R169.2, U74.116 (BWAIT#)
/PCMCIA/BWE#: J10.100 (BWE#), U74.99 (BWE#)
/PCMCIA/BWP: J10.136 (BWP_IOIS16#), R178.1, U74.131 (BWP/IOIS16#)
AEN: U74.187 (AEN); also elsewhere on the board
Chipset_SA16: U74.184 (SA16); also elsewhere on the board
D28_1: U70.7 (12V), U70.24 (12V); also elsewhere on the board
FCS_IOCHRDY: U74.188 (IOCHRDY); also elsewhere on the board
GND: C87.2 (-), C114.1, C115.1, C116.2, C119.2, C122.2, C124.1 (+), C126.2 (-), C273.2 (-), C276.2, C278.1 (+), C279.2 (-), J10.1 (GND), J10.2 (GND), J10.3 (GND), J10.68 (GND), J10.69 (GND), J10.70 (GND), J10.71 (GND), J10.72 (GND), J10.73 (GND), J10.138 (GND), J10.139 (GND), J10.140 (GND), R126.2, R160.1, R379.1, U70.12 (GND), U74.31 (GND), U74.70 (GND), U74.79 (GND), U74.111 (GND), U74.140 (GND), U74.192 (GND), U74.201 (POWERGOOD); also elsewhere on the board
IOCS16#: U74.158 (IOCS16#); also elsewhere on the board
IOR#: U74.185 (IOR#); also elsewhere on the board
IOW#: U74.186 (IOW#); also elsewhere on the board
IRQ3: R115.2, U74.170 (IRQ3); also elsewhere on the board
IRQ4: R384.2, U74.172 (IRQ4); also elsewhere on the board
IRQ5: R387.2, U74.174 (IRQ5); also elsewhere on the board
IRQ7: R389.2, U74.177 (IRQ7); also elsewhere on the board
IRQ9: R325.2, U74.198 (IRQ9); also elsewhere on the board
IRQ10: R394.2, U74.156 (IRQ10); also elsewhere on the board
IRQ11: R396.2, U74.154 (IRQ11); also elsewhere on the board
IRQ14: U74.148 (IRQ14); also elsewhere on the board
IRQ15: R391.2, U74.150 (IRQ15); also elsewhere on the board
LA17: U74.146 (LA17); also elsewhere on the board
LA18: U74.147 (LA18); also elsewhere on the board
LA19: U74.149 (LA19); also elsewhere on the board
LA20: U74.151 (LA20); also elsewhere on the board
LA21: U74.153 (LA21); also elsewhere on the board
LA22: U74.155 (LA22); also elsewhere on the board
LA23: U74.157 (LA23); also elsewhere on the board
MEMCS16#: R316.2, U74.160 (MEMCS16#); also elsewhere on the board
MEMR#: U74.145 (MEMR#); also elsewhere on the board
MEMW#: U74.144 (MEMW#); also elsewhere on the board
unnamed: U70.6 (A_VCC3#), U74.4 (AVCC3EN#)
unnamed: U70.5 (A_VCC5#), U74.5 (AVCC5EN#)
unnamed: U70.3 (A_VPP_PGM), U74.1 (AVPP_EN1)
unnamed: U70.4 (A_VPP_VCC), U74.2 (AVPP_EN0)
unnamed: U70.26 (B_VCC3#), U74.206 (BVCC3EN#)
unnamed: U70.27 (B_VCC5#), U74.207 (BVCC5EN#)
unnamed: U70.29 (B_VPP_PGM), U74.204 (BVPP_EN1)
unnamed: U70.28 (B_VPP_VCC), U74.205 (BVPP_EN0)
unnamed: R363.1, U70.14 (SHDN#)
unnamed: U38.2, U74.208 (CS#)
unnamed: R162.1, U74.203 (INTR#)
unnamed: R317.1, U74.163 (SYSCLK)
PCMCIA_BALE: U74.166 (BALE); also elsewhere on the board
PCMCIA_CLK: R317.2; also elsewhere on the board
PCMCIA_CS: R160.2, U38.6; also elsewhere on the board
PCMCIA_REFRESH: U74.180 (REFRESH#); also elsewhere on the board
PCMCIA_SBHE#: U74.159 (SBHE#); also elsewhere on the board
PCMCIA_Sound: U74.202 (SPKROUT#); also elsewhere on the board
PCMCIA_ZEROWS#: U74.191 (ZEROWS#); also elsewhere on the board
PNET1: C114.2, C115.2, C122.1, R117.1, R162.2, R165.2, R177.1, R312.1, U70.15 (3V), U70.16 (3V), U70.17 (3V), U74.27 (VCC), U74.138 (VCCAT), U74.195 (VCCAT); also elsewhere on the board
PNET5: C276.1, R363.2, U70.1 (5V), U70.2 (5V), U70.25 (VDD), U70.30 (5V); also elsewhere on the board
PNET7: R115.1, R316.1, R325.1, R384.1, R387.1, R389.1, R391.1, R394.1, R396.1; also elsewhere on the board
PNET9: C116.1, C278.2 (-), C279.1 (+), J10.104 (VCC), J10.105 (VCC), R166.1, R169.1, R170.1, R172.2, R175.2, R178.2, R379.2, U70.20 (BVCC), U74.88 (VCCSLOT#1), U74.117 (VCCSLOT#1)
PNET10: C87.1 (+), C119.1, C126.1 (+), J10.34 (VCC), J10.35 (VCC), R126.1, R163.1, R164.1, R168.1, R174.1, R176.1, R179.1, U70.10 (AVCC), U74.24 (VCCSLOT#0), U74.52 (VCCSLOT#0)
RESET: U74.7 (RESETDRV); also elsewhere on the board
RIOUT#: U74.133 (RIOUT#); also elsewhere on the board
SA0: U74.161 (SA0); also elsewhere on the board
SA1: U74.162 (SA1); also elsewhere on the board
SA2: U74.164 (SA2); also elsewhere on the board
SA3: U74.165 (SA3); also elsewhere on the board
SA4: U74.167 (SA4); also elsewhere on the board
SA5: U74.168 (SA5); also elsewhere on the board
SA6: U74.169 (SA6); also elsewhere on the board
SA7: U74.171 (SA7); also elsewhere on the board
SA8: U74.173 (SA8); also elsewhere on the board
SA9: U74.175 (SA9); also elsewhere on the board
SA10: U74.176 (SA10); also elsewhere on the board
SA11: U74.178 (SA11); also elsewhere on the board
SA12: U74.179 (SA12); also elsewhere on the board
SA13: U74.181 (SA13); also elsewhere on the board
SA14: U74.182 (SA14); also elsewhere on the board
SA15: U74.183 (SA15); also elsewhere on the board
SD0: U74.189 (SD0); also elsewhere on the board
SD1: U74.190 (SD1); also elsewhere on the board
SD2: U74.193 (SD2); also elsewhere on the board
SD3: U74.194 (SD3); also elsewhere on the board
SD4: U74.196 (SD4); also elsewhere on the board
SD5: U74.197 (SD5); also elsewhere on the board
SD6: U74.199 (SD6); also elsewhere on the board
SD7: U74.200 (SD7); also elsewhere on the board
SD8: U74.143 (SD8); also elsewhere on the board
SD9: U74.142 (SD9); also elsewhere on the board
SD10: U74.141 (SD10); also elsewhere on the board
SD11: U74.139 (SD11); also elsewhere on the board
SD12: U74.137 (SD12); also elsewhere on the board
SD13: U74.136 (SD13); also elsewhere on the board
SD14: U74.135 (SD14); also elsewhere on the board
SD15: U74.134 (SD15); also elsewhere on the board

Notes on the sheet:
Device_Data_BUS
Device_Address_BUS

Schematic: Memory.kicad_sch, PC110

Parts:
C95, C103, C104, C105: 150nF; C_0402_1005Metric
C101: 180nF; C_0402_1005Metric
C102: 120nF; C_0402_1005Metric
C106: 1nF; C_0402_1005Metric
J15: RAM Module
R94, R102, R105, R148, R158: 470k; R_0402_1005Metric
R101, R103, R106, R154, R159, R261, R272, R274: 33; R_0402_1005Metric
R150, R151, R153, R155, R157: 100k; R_0402_1005Metric
RA5: 470k; R-array
U28, U33: M5M4V16160BTP; RAMchip

Connections:
/Memory/RAM_LCASL#: J15.48 (LCASL#), R272.2, RA5.3 (R3.1), U33.32 (LCAS#)
/Memory/RAM_LCASU#: J15.12 (LCASU#), R274.2, RA5.1 (R1.1), U28.32 (LCAS#)
/Memory/RAM_UCASL#: J15.47 (UCASL#), R159.1, RA5.4 (R4.1), U33.31 (UCAS#)
/Memory/RAM_UCASU#: J15.13 (UCASU#), R261.2, RA5.2 (R2.1), U28.31 (UCAS#)
CPU_D0: J15.1 (D0), U28.2 (DQ0); also elsewhere on the board
CPU_D1: J15.2 (D1), U28.3 (DQ1); also elsewhere on the board
CPU_D2: J15.3 (D2), U28.4 (DQ2); also elsewhere on the board
CPU_D3: J15.4 (D3), U28.5 (DQ3); also elsewhere on the board
CPU_D4: J15.6 (D4), U28.7 (DQ4); also elsewhere on the board
CPU_D5: J15.7 (D5), U28.8 (DQ5); also elsewhere on the board
CPU_D6: J15.8 (D6), U28.9 (DQ6); also elsewhere on the board
CPU_D7: J15.9 (D7), U28.10 (DQ7); also elsewhere on the board
CPU_D8: J15.51 (D8), U28.35 (DQ8); also elsewhere on the board
CPU_D9: J15.52 (D9), U28.36 (DQ9); also elsewhere on the board
CPU_D10: J15.53 (D10), U28.37 (DQ10); also elsewhere on the board
CPU_D11: J15.54 (D11), U28.38 (DQ11); also elsewhere on the board
CPU_D12: J15.56 (D12), U28.40 (DQ12); also elsewhere on the board
CPU_D13: J15.57 (D13), U28.41 (DQ13); also elsewhere on the board
CPU_D14: J15.58 (D14), U28.42 (DQ14); also elsewhere on the board
CPU_D15: J15.59 (D15), U28.43 (DQ15); also elsewhere on the board
CPU_D16: J15.22 (D16), U33.2 (DQ0); also elsewhere on the board
CPU_D17: J15.23 (D17), U33.3 (DQ1); also elsewhere on the board
CPU_D18: J15.24 (D18), U33.4 (DQ2); also elsewhere on the board
CPU_D19: J15.25 (D19), U33.5 (DQ3); also elsewhere on the board
CPU_D20: J15.27 (D20), U33.7 (DQ4); also elsewhere on the board
CPU_D21: J15.28 (D21), U33.8 (DQ5); also elsewhere on the board
CPU_D22: J15.29 (D22), U33.9 (DQ6); also elsewhere on the board
CPU_D23: J15.30 (D23), U33.10 (DQ7); also elsewhere on the board
CPU_D24: J15.32 (D24), U33.35 (DQ8); also elsewhere on the board
CPU_D25: J15.33 (D25), U33.36 (DQ9); also elsewhere on the board
CPU_D26: J15.34 (D26), U33.37 (DQ10); also elsewhere on the board
CPU_D27: J15.35 (D27), U33.38 (DQ11); also elsewhere on the board
CPU_D28: J15.37 (D28), U33.40 (DQ12); also elsewhere on the board
CPU_D29: J15.38 (D29), U33.41 (DQ13); also elsewhere on the board
CPU_D30: J15.39 (D30), U33.42 (DQ14); also elsewhere on the board
CPU_D31: J15.40 (D31), U33.43 (DQ15); also elsewhere on the board
GND: C95.2 (-), C101.1 (+), C102.1, C103.2, C104.1, C105.2, C106.1, J15.10 (GND), J15.26 (GND), J15.36 (GND), J15.55 (GND), R150.2, R151.1, R153.1, R155.1, U28.23 (GND), U28.30 (OE#), U28.39 (GND), U28.44 (GND), U33.23 (GND), U33.30 (OE#), U33.39 (GND), U33.44 (GND); also elsewhere on the board
unnamed: J15.11 (RAS2), R102.2, R103.1
unnamed: J15.49 (RAS3), R94.2, R106.1
unnamed: R101.1, R105.2, U28.15 (RAS#), U33.15 (RAS#)
PNET1: C95.1 (+), C101.2 (-), C102.2, C103.1, C104.2, C105.1, C106.2, J15.5 (VCC), J15.14 (VCC), J15.21 (VCC), R94.1, R102.1, R105.1, R148.2, R157.2, R158.2, RA5.5 (R4.2), RA5.6 (R3.2), RA5.7 (R2.2), RA5.8 (R1.2), U28.1 (VCC), U28.6 (VCC), U28.22 (VCC), U33.1 (VCC), U33.6 (VCC), U33.22 (VCC); also elsewhere on the board
RAMWE#: J15.50 (WE#), R154.1, U28.14 (W#), U33.14 (W#)
RAM_A0: J15.17 (A0), U28.18 (A0), U33.18 (A0); also elsewhere on the board
RAM_A1: J15.18 (A1), U28.19 (A1), U33.19 (A1); also elsewhere on the board
RAM_A2: J15.19 (A2), U28.20 (A2), U33.20 (A2); also elsewhere on the board
RAM_A3: J15.20 (A3), U28.21 (A3), U33.21 (A3); also elsewhere on the board
RAM_A4: J15.41 (A4), R155.2, U28.24 (A4), U33.24 (A4); also elsewhere on the board
RAM_A5: J15.42 (A5), R153.2, U28.25 (A5), U33.25 (A5); also elsewhere on the board
RAM_A6: J15.43 (A6), R150.1, U28.26 (A6), U33.26 (A6); also elsewhere on the board
RAM_A7: J15.44 (A7), U28.27 (A7), U33.27 (A7); also elsewhere on the board
RAM_A8: J15.45 (A8), U28.28 (A8), U33.28 (A8); also elsewhere on the board
RAM_A9: J15.46 (A9), U28.29 (A9), U33.29 (A9); also elsewhere on the board
RAM_A10: J15.16 (A10), R151.2, U28.17 (A10), U33.17 (A10); also elsewhere on the board
RAM_A11: J15.15 (A11), R157.1, U28.16 (A11), U33.16 (A11); also elsewhere on the board
RAM_ID0: J15.60 (ID0), R158.1; also elsewhere on the board
RAM_ID1: J15.31 (ID1), R148.1; also elsewhere on the board
U61_RAM_LCASL#: R272.1; also elsewhere on the board
U61_RAM_LCASU#: R274.1; also elsewhere on the board
U61_RAM_RAMWE#: R154.2; also elsewhere on the board
U61_RAM_RAS0: R101.2; also elsewhere on the board
U61_RAM_RAS2: R103.2; also elsewhere on the board
U61_RAM_RAS3: R106.2; also elsewhere on the board
U61_RAM_UCASL#: R159.2; also elsewhere on the board
U61_RAM_UCASU#: R261.1; also elsewhere on the board

Notes on the sheet:
RAM_ADDRESS_BUS
CPU_DATA_BUS
