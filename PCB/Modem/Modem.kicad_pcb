# Repository ahmadexp/Open-Source-PC110 (continued)

## KiCad design Mods/PC110-ITX-all-in-one/PC110.kicad_pcb (continued)

Schematic: Audio.kicad_sch, PC110

Parts:
C166, C172, C180, C197: 1uF; C_0603_1608Metric
C167, C201, C203: 1nF; C_0402_1005Metric
C168, C171, C174, C179, C215, C216: 270nF; C_0603_1608Metric
C169, C173, C176, C187, C188, C198, C213, C218, C222, C223: 10uF; C_1206_3216Metric
C170, C191, C196, C219: DNP; C_0402_1005Metric; not fitted
C175, C182, C195, C200, C211: 100nF; C_0402_1005Metric
C177: 330nF; C_0603_1608Metric
C178: 5.6nF; C_0402_1005Metric
C181, C190, C202, C204, C205, C207, C209, C224: 150nF; C_0402_1005Metric
C183, C221: 300nF; C_0603_1608Metric
C184, C194: 100pF; C_0402_1005Metric
C185, C210: 10nF; C_0603_1608Metric
C186: DNP; C_1206_3216Metric; not fitted
C189, C192, C193: DNP; C_0402_1005Metric
C199: 2.7uF; C_0805_2012Metric
C206: 120nF; C_0402_1005Metric
C208: 100nF; C_0603_1608Metric
C212, C217: 22pF; C_0402_1005Metric
C214: 250nF; C_0603_1608Metric
C220: 1.5nF; C_0402_1005Metric
D46, D50: DNP; 3D; not fitted
D47, D48: 3D
D49: N; SOT-416L
J11: Audio-Jack
J12: SPKR
L12, L13, L14, L15, L16: 1.5uH; L_0603_1608Metric
Q37: ST3; SOT-416L
R272, R273, R290, R291, R299, R300, R301, R302, R304, R308, R328: 470k; R_0402_1005Metric
R274, R276, R282, R292: 2.2k; R_0402_1005Metric
R275, R289, R293, R309, R312, R316: 100k; R_0402_1005Metric
R277, R278, R318: 1k; R_0402_1005Metric
R279: 56; R_1206_3216Metric
R280, R285, R295, R297, R303, R305, R322, R323, R324: 0; R_0402_1005Metric
R281, R284, R286, R287, R288, R294, R307: 10k; R_0402_1005Metric
R283: 100; R_0805_2012Metric
R296: 0; R_0805_2012Metric
R298: 47; R_0402_1005Metric
R306: 4.7k; R_0402_1005Metric
R310, R327: DNP; R_0402_1005Metric
R311, R313, R314, R315, R317, R319, R320, R321: DNP; R_0402_1005Metric; not fitted
R325, R326: 6.8k; R_0402_1005Metric
R329: 120; R_1206_3216Metric
U1: SN74LV02; TSSOP-14_4.4x5mm_P0.65mm
U32: 74HC14; TSSOP-14_4.4x5mm_P0.65mm
U36: 7W14; sso-8
U47: 3414A; SOIC-8
U48: NJM2904M; soic-8-small
U49: DS1669; SOIC-8
U50: VT74; TSSOP-14_4.4x5mm_P0.65mm
U51: Y3014; SOP-16
U52: 3F01; SOT-23-5
U53: YM3812; SOP-24
U54: 74LV126; TSSOP-14_4.4x5mm_P0.65mm
U55: HD151015; SSOP-24_5.3x8.2mm_P0.65mm
U56: SN74LV126; TSSOP-14_4.4x5mm_P0.65mm
U57: LM4861; SOIC-8-narrow
U58: SN74LV32; TSSOP-14_4.4x5mm_P0.65mm
U59: ES488F; QFN-52
U60: 3E00; SOT-23-5
X4: 89G6821; XTAL-1

Connections:
/Audio/Enable_YMF_Bus: R299.1, U32.5, U52.1 (OUT), U53.3 (IC#), U54.1, U54.4, U54.10, U54.13
/Audio/PCMCIA_KB_sound: C174.2 (-), R275.1
/Audio/YMFDAC_OUTPUT: C168.2 (-), R274.1
Bowman_Audio_Vol_Dn: U49.7 (DnC); also elsewhere on the board
Bowman_Audio_Vol_Up: U49.2 (UpC); also elsewhere on the board
Chipset_Sound: R288.2; also elsewhere on the board
D11_2: C206.2, D50.2 (A), R322.1, U60.2 (VDD); also elsewhere on the board
ESS_AEN: U59.40 (AEN); also elsewhere on the board
ESS_CLK: R327.1; also elsewhere on the board
ESS_DACK1#: U59.36 (DACK1#); also elsewhere on the board
ESS_DRDY: U1.6, U59.21 (DRDY)
ESS_IRQ1: R318.1, U59.16 (IRQ1); also elsewhere on the board
ESS_IRQ2: U59.18 (IRQ2); also elsewhere on the board
ESS_Sound: C171.1 (+), U59.9 (LineOut)
GND: C166.1, C169.2, C170.1, C173.2, C175.1, C177.1, C178.1, C180.2, C182.2, C185.2, C189.2, C190.2, C191.1, C192.1, C193.1, C194.2, C195.2, C198.1, C199.2, C201.1, C202.1, C204.1, C205.2, C206.1, C207.1, C208.1, C209.2, C211.2, C212.1, C213.2 (-), C216.2 (-), C217.2, C218.1 (+), C219.1 (+), C220.1 (+), C221.2 (-), C222.2, C223.2, C224.1, D47.1 (A), D47.3 (A), D49.1, D49.2, L13.1 (+), Q37.1 (E), R273.2, R291.1, R292.1, R299.2, R300.2, R308.2, R309.1, R312.2, R318.2, R324.2, R328.2, U47.4 (V-), U49.4 (RL), U49.5 (V-), U50.7 (GND), U52.3 (GND), U53.12 (GND), U54.7 (GND), U55.12 (GND), U55.13 (GND), U57.7 (GND), U59.5 (GND), U59.22 (GND), U59.26 (GND), U59.33 (GND), U60.3 (GND), X4.3; also elsewhere on the board
IOR#: R310.1, U1.3, U1.5; also elsewhere on the board
KB_Sound: R287.1; also elsewhere on the board
MIC_J17: R303.2; also elsewhere on the board
MIC_in_pin: C191.2, J11.4 (MI), L16.2 (-)
Modem_Audio_Out: R276.1; also elsewhere on the board
unnamed: C167.1 (+), C172.2 (-), R278.1, U47.7
unnamed: C167.2 (-), R274.2, R275.2, R276.2, R277.2, R278.2, U47.6 (-)
unnamed: C168.1 (+), C170.2, R280.1, U48.7
unnamed: C171.2 (-), R277.1
unnamed: C172.1 (+), U49.1 (RH)
unnamed: C174.1 (+), Q37.3 (C), R281.2
unnamed: C177.2, R284.2
unnamed: C179.1 (+), U49.6 (RW)
unnamed: C179.2 (-), R290.2, R291.2, U47.3 (+)
unnamed: C180.1, R289.2, R290.1
unnamed: C183.1 (+), R286.2
unnamed: C184.1 (+), R284.1, R294.1, U47.2 (-)
unnamed: C184.2 (-), C186.2 (-), C187.2 (-), R294.2, U47.1
unnamed: C186.1 (+), C187.1 (+), L12.1 (+)
unnamed: C188.2, C200.2, R296.1
unnamed: C196.1, U56.11
unnamed: C203.1 (+), R306.1, R316.1, U57.4 (IN-)
unnamed: C203.2 (-), J12.2, R316.2, U57.5 (OUT+)
unnamed: C210.1 (+), U59.4 (MIC)
unnamed: C210.2 (-), R323.1, R326.1
unnamed: C213.1 (+), R325.2, R326.2
unnamed: C214.1 (+), U59.1 (FoutR)
unnamed: C214.2 (-), C219.2 (-), U59.2 (CinR)
unnamed: C215.1 (+), U59.7 (FoutL)
unnamed: C215.2 (-), C220.2 (-), U59.8 (CinL)
unnamed: C216.1 (+), U59.10 (ByPass)
unnamed: C218.2 (-), C221.1 (+), R328.1, U59.11 (ByPass)
unnamed: D47.2 (K), Q37.2 (B), R286.1, R287.2, R288.1
unnamed: D48.2 (K), U32.6
unnamed: D50.1 (K), U36.3, U60.1 (OUT)
unnamed: J11.3 (G), L13.2 (-)
unnamed: C192.2, J11.5 (MO), L15.2 (-)
unnamed: C189.1, J11.2 (SI), L12.2 (-)
unnamed: C193.2, J11.1 (SO), L14.1 (+)
unnamed: J12.1, U57.8 (OUT-)
unnamed: C194.1, L14.2 (-), R306.2
unnamed: L15.1 (+), R303.1
unnamed: L16.1 (+), R323.2
unnamed: R292.2, R295.1, U48.1
unnamed: R305.2, U1.10
unnamed: U1.1, U1.8
unnamed: U1.4, U1.9
unnamed: C166.2, R272.1, R273.1, U47.5 (+)
unnamed: C188.1, R297.1, U48.3 (+)
unnamed: R295.2, U48.2 (-), U51.16 (MP)
unnamed: R282.1, U48.5 (+)
unnamed: R280.2, U48.6 (-)
unnamed: C176.1, C181.1, R283.1, U48.8 (V+), U51.1 (VDD)
unnamed: C176.2, C181.2, R296.2, U48.4 (V-), U51.12 (GND)
unnamed: U50.2 (D), U50.6 (~Q), U50.11 (C)
unnamed: R298.1, U50.8 (~Q), U50.12 (D)
unnamed: U51.10 (Clock), U53.23 (SY)
unnamed: U51.4 (LOAD), U53.20 (SH)
unnamed: R297.2, U51.14 (RB)
unnamed: U51.7 (SD), U53.21 (MO)
unnamed: C178.2, R282.2, U51.2 (toBUFF)
unnamed: C185.1, D46.3 (A), U52.5 (CD)
unnamed: C182.1, D46.1 (A), R285.2, U52.2 (VDD)
unnamed: R300.1, U53.4 (AO), U54.11
unnamed: R301.2, U53.7 (CS#), U54.3
unnamed: R311.2, U53.10 (D0), U55.22 (B0), U59.23 (D0)
unnamed: R313.2, U53.11 (D1), U55.21 (B1), U59.24 (D1)
unnamed: R314.2, U53.13 (D2), U55.20 (B2), U59.25 (D2)
unnamed: R315.2, U53.14 (D3), U55.19 (B3), U59.28 (D3)
unnamed: R317.2, U53.15 (D4), U55.18 (B4), U59.29 (D4)
unnamed: R319.1, U53.16 (D5), U55.17 (B5), U59.30 (D5)
unnamed: R320.1, U53.17 (D6), U55.16 (B6), U59.31 (D6)
unnamed: R321.1, U53.18 (D7), U55.15 (B7), U59.32 (D7)
unnamed: R298.2, U53.24 (M)
unnamed: R302.2, U53.6 (RD#), U54.6
unnamed: R304.2, U53.5 (WR#), U54.8
unnamed: R309.2, U55.11 (A8)
unnamed: R312.1, U55.14 (B8)
unnamed: R305.1, R310.2, U55.2 (DIR)
unnamed: C196.2, D48.1 (A), D48.3 (A), R307.2, U55.23 (G#)
unnamed: C200.1, U55.24 (VCCB), U59.44 (VCC_Bus)
unnamed: C199.1, U57.2 (Bypass), U57.3 (IN+)
unnamed: C197.2, D49.3, R308.1, U57.1 (~SD)
unnamed: C222.1, C223.1, C224.2, R329.1, U59.6 (CMR)
unnamed: U58.11, U59.37 (IOR)
unnamed: U58.8, U59.38 (IOW)
unnamed: R324.1, U59.52 (REF)
unnamed: U36.5, U59.39 (RESET)
unnamed: C217.1, R327.2, U59.34 (Xin), X4.1
unnamed: C212.2, U59.35 (Xout), X4.2
unnamed: C208.2, U60.5 (CD)
PCMCIA_Sound: C183.2 (-), R293.2; also elsewhere on the board
PNET1: C195.1, C201.2, C204.2, C205.1, R293.1, R307.1, U55.1 (VCCA), U56.13; also elsewhere on the board
PNET2: C190.1, C198.2, C202.2, C211.1, D46.2 (K), R279.2, R283.2, R285.1, R301.1, R302.1, R304.1, U50.1 (~R), U50.4 (~S), U50.10 (~S), U50.13 (~R), U50.14 (VCC), U53.1 (VCC), U57.6 (VDD); also elsewhere on the board
PNET5: C207.2, D50.3 (common), R311.1, R313.1, R314.1, R315.1, R317.1, R319.2, R320.2, R321.2, R322.2, R329.2, U54.14 (VCC), U59.20 (VCC), U59.27 (VCC); also elsewhere on the board
PNET6: C169.1, C173.1, C175.2, C209.1, R272.2, R279.1, R281.1, R289.1, R325.1, U47.8 (V+), U49.8 (V+)
PWRGD_shift: C197.1; also elsewhere on the board
PWRGD_shift_buff: U58.10, U58.13; also elsewhere on the board
SA1: U59.42 (A1); also elsewhere on the board
SA2: U59.43 (A2); also elsewhere on the board
SA3: U59.45 (A3); also elsewhere on the board
SA4: U59.46 (A4); also elsewhere on the board
SA5: U59.47 (A5); also elsewhere on the board
SA6: U59.48 (A6); also elsewhere on the board
SA7: U59.49 (A7); also elsewhere on the board
SA8: U59.50 (A8); also elsewhere on the board
SA9: U59.51 (A9); also elsewhere on the board
SD0: U55.3 (A0); also elsewhere on the board
SD1: U55.4 (A1); also elsewhere on the board
SD2: U55.5 (A2); also elsewhere on the board
SD3: U55.6 (A3); also elsewhere on the board
SD4: U55.7 (A4); also elsewhere on the board
SD5: U55.8 (A5); also elsewhere on the board
SD6: U55.9 (A6); also elsewhere on the board
SD7: U55.10 (A7); also elsewhere on the board
YMF_CLK: U50.3 (C); also elsewhere on the board
YMF_CS#_Buf: U1.2, U54.2, U56.12, U59.14 (DIR)
YMF_RD#_Buf: U54.5, U58.12; also elsewhere on the board
YMF_SA0_A0: U54.12, U59.41 (A0); also elsewhere on the board
YMF_WR#_Buf: U54.9, U58.9; also elsewhere on the board

Notes on the sheet:
Device_Data_BUS
Device_Address_BUS

Schematic: ROM.kicad_sch

Parts:
C84, C85: 150nF; C_0402_1005Metric
C86: 150nF; C_0603_1608Metric
D7: 3D; SOT-416L
D8: N; SOT-416L
Q4: 7C; TSOT-23
Q5: 8C; SOT-523
R110, R111: 470k; R_0402_1005Metric
R112: 10k; R_0402_1005Metric
R113: 100k; R_0402_1005Metric
R114: 47k; R_0402_1005Metric
U14: MSM538032E; SOP48
U15: 28F002BX; Flash-40
U16: E3; SOT-353
U17: E4; SOT-353

Connections:
BIOS_SA17: U15.40 (A17); also elsewhere on the board
Bowman5_Buff: U16.1; also elsewhere on the board
Chipset_BIOS_CE#: U15.22 (CE#); also elsewhere on the board
Chipset_SA16: U15.1 (A16); also elsewhere on the board
D28_1: Q4.2 (E); also elsewhere on the board
GND: C84.2 (-), C85.1 (+), C86.2 (-), Q5.2 (E), R110.1, R111.2, U14.15 (VSS), U15.23 (GND), U15.39 (GND), U16.3 (GND), U17.3 (GND); also elsewhere on the board
MEMR#: U14.16 (OE#), U15.24 (OE#); also elsewhere on the board
MEMW#: U17.1; also elsewhere on the board
unnamed: C86.1 (+), D7.1 (A), Q4.3 (C), R111.1, U15.11 (VPP)
unnamed: D7.2 (K), R110.2, U15.10 (RP#)
unnamed: D8.1, D8.2, R114.2, U17.2
unnamed: Q4.1 (B), R112.2
unnamed: Q5.1 (B), R113.2
unnamed: Q5.3 (C), R112.1
unnamed: R113.1, U16.4
unnamed: U15.9 (WE#), U17.4
OKI_CE#: U14.14 (CE#); also elsewhere on the board
OKI_SA12: U14.40 (A12); also elsewhere on the board
OKI_SA13: U14.39 (A13); also elsewhere on the board
OKI_SA14: U14.38 (A14); also elsewhere on the board
OKI_SA15: U14.37 (A15); also elsewhere on the board
OKI_SA16: U14.36 (A16); also elsewhere on the board
OKI_SA17: U14.5 (A17); also elsewhere on the board
OKI_SA18: U14.4 (A18); also elsewhere on the board
OKI_SA19: U14.45 (A19); also elsewhere on the board
PNET5: U16.5 (VCC), U17.5 (VCC); also elsewhere on the board
PNET7: C84.1 (+), C85.2 (-), R114.1, U14.25 (VCC), U14.35 (BHE), U15.30 (VCC), U15.31 (VCC); also elsewhere on the board
PWRGD: D7.3 (A); also elsewhere on the board
PWRGD_shift_buff: U16.2; also elsewhere on the board
Pluto_BIOS_WR_EN: D8.3; also elsewhere on the board
SA0: U15.21 (A0); also elsewhere on the board
SA1: U14.13 (A0), U15.20 (A1); also elsewhere on the board
SA2: U14.12 (A1), U15.19 (A2); also elsewhere on the board
SA3: U14.11 (A2), U15.18 (A3); also elsewhere on the board
SA4: U14.10 (A3), U15.17 (A4); also elsewhere on the board
SA5: U14.9 (A4), U15.16 (A5); also elsewhere on the board
SA6: U14.8 (A5), U15.15 (A6); also elsewhere on the board
SA7: U14.7 (A6), U15.14 (A7); also elsewhere on the board
SA8: U14.6 (A7), U15.8 (A8); also elsewhere on the board
SA9: U14.44 (A8), U15.7 (A9); also elsewhere on the board
SA10: U14.43 (A9), U15.36 (A10); also elsewhere on the board
SA11: U14.42 (A10), U15.6 (A11); also elsewhere on the board
SA12: U14.41 (A11), U15.5 (A12); also elsewhere on the board
SA13: U15.4 (A13); also elsewhere on the board
SA14: U15.3 (A14); also elsewhere on the board
SA15: U15.2 (A15); also elsewhere on the board
SD0: U14.17 (D0), U15.25 (DQ0); also elsewhere on the board
SD1: U14.19 (D1), U15.26 (DQ1); also elsewhere on the board
SD2: U14.21 (D2), U15.27 (DQ2); also elsewhere on the board
SD3: U14.23 (D3), U15.28 (DQ3); also elsewhere on the board
SD4: U14.26 (D4), U15.32 (DQ4); also elsewhere on the board
SD5: U14.28 (D5), U15.33 (DQ5); also elsewhere on the board
SD6: U14.30 (D6), U15.34 (DQ6); also elsewhere on the board
SD7: U14.32 (D7), U15.35 (DQ7); also elsewhere on the board
SD8: U14.18 (D8); also elsewhere on the board
SD9: U14.20 (D9); also elsewhere on the board
SD10: U14.22 (D10); also elsewhere on the board
SD11: U14.24 (D11); also elsewhere on the board
SD12: U14.27 (D12); also elsewhere on the board
SD13: U14.29 (D13); also elsewhere on the board
SD14: U14.31 (D14); also elsewhere on the board
SD15: U14.33 (D15); also elsewhere on the board

Notes on the sheet:
Device_Data_BUS
Device_Address_BUS
OKI_Extra_Address

Schematic: DockStation.kicad_sch, PC110

Parts:
C255, C266, C268, C269, C270: 150nF; C_0402_1005Metric
C256, C259, C260, C261: 120nF; C_0402_1005Metric
C257, C267, C271, C282: 100nF; C_0402_1005Metric
C258, C262, C263, C265: 220pF; C_0402_1005Metric
C264, C276: 300nF; C_0603_1608Metric
C272, C277: 1uF; C_0603_1608Metric
C273: 150nF; C_0603_1608Metric
C274, C275: 10uF; C_1206_3216Metric
C278: DNP; C_0402_1005Metric; not fitted
C279: 470nF; C_0603_1608Metric
C280, C281: 180nF; C_0402_1005Metric
C283: 1nF; C_0402_1005Metric
D52, D53: s.3 5F; Diode
D54: 3D; SOT-416L
D55, D56, D58, D59, D60: K; SOT-416
D57: 3D
EM5: R-array
F3: 0.5A; Fuse_1206_3216Metric
F4: 1.0A; Fuse_1206_3216Metric
J17: PS2
J18: Modem-Connector
L17: 300nH; L_0805_2012Metric
L18: 1.5uH; L_0603_1608Metric
Q40, Q41, Q44: BH RT; SOT-89-3
Q42: 6D; SOT-23
Q43: 8B; SOT-416
R375, R377, R387, R388, R389, R390, R391, R392, R393, R394, R413, R419: 0; R_0603_1608Metric
R376: 0; R_0805_2012Metric
R378, R379, R380, R382, R383, R384, R385, R386, R403, R405, R407, R408, R409, R410, R411, R412, R414, R415, R420, R421, R422, R423, R424: 470k; R_0402_1005Metric
R381: 1.2k; R_0402_1005Metric
R395: 22k; R_0402_1005Metric
R396, R398: 220; R_0402_1005Metric
R397: 56; R_0603_1608Metric
R399: 7.5k; R_0402_1005Metric
R400, R406, R416, R417, R418: 10k; R_0402_1005Metric
R401: 8.2; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R402: 300; R_0402_1005Metric
R404: 4.7k; R_0402_1005Metric
RA5: 10k; R-array
U36: 7W14; sso-8
U56: SN74LV126; TSSOP-14_4.4x5mm_P0.65mm
U58: SN74LV32; TSSOP-14_4.4x5mm_P0.65mm
U72: SN74LVT125; TSSOP-14_4.4x5mm_P0.65mm
U73: 7W32; sso-8
U74: 7W126; sso-8
U75: HSDL-1000 X03; IRDA
U76: EA; SOT-353

Connections:
/Docking Station and Modem/FDD_PWR: C266.2 (-), C267.1 (+), C272.2 (-), Q41.2 (C)
/Docking Station and Modem/J13_53: R375.1 (+)
/Docking Station and Modem/PD0: R387.1 (+)
/Docking Station and Modem/PD1: R388.1 (+)
/Docking Station and Modem/PD2: R389.1 (+)
/Docking Station and Modem/PD3: R390.1 (+)
/Docking Station and Modem/PD4: R391.1 (+)
/Docking Station and Modem/PD5: R392.1 (+)
/Docking Station and Modem/PD6: R393.1 (+)
/Docking Station and Modem/PD7: R394.1 (+)
/Docking Station and Modem/PNET5_Q1: C260.2 (-), F3.1, L17.1, RA5.1 (R1.1), RA5.2 (R2.1), RA5.3 (R3.1), RA5.4 (R4.1)
/Docking Station and Modem/PWR_IN+_D: D52.2 (A), D53.2 (A)
/Docking Station and Modem/PWR_IN-: R375.2 (-)
/Docking Station and Modem/RXD2: R385.1, U74.5 (Q)
/Docking Station and Modem/TXD2: U74.6 (~CLR)
Enable_IRDA_Buf: Q42.1 (B), R399.2, U72.4, U72.10, U74.1 (C), U74.7 (~PRE); also elsewhere on the board
FDC_CTS1#: J18.8 (CTS1#), R411.1; also elsewhere on the board
FDC_CTS2#: R382.2; also elsewhere on the board
FDC_DCD1#: J18.4 (DCD1#), R408.1; also elsewhere on the board
FDC_DCD2#: R383.2; also elsewhere on the board
FDC_DRATE0: R405.2, U72.2; also elsewhere on the board
FDC_DRATE0#: U72.3; also elsewhere on the board
FDC_DRATE1: R407.2, U72.12; also elsewhere on the board
FDC_DRATE1#: U72.11; also elsewhere on the board
FDC_DSKCHG#: R422.2; also elsewhere on the board
FDC_DSR1: J18.7 (DSR1), R410.1; also elsewhere on the board
FDC_DSR2#: R386.2; also elsewhere on the board
FDC_DTR1#: R416.1, U56.9; also elsewhere on the board
FDC_INDEX#: R424.2; also elsewhere on the board
FDC_IRRX_RXD2: U72.8, U74.3 (~Q); also elsewhere on the board
FDC_IRTX_TXD2: R378.2, U72.5, U74.2 (D); also elsewhere on the board
FDC_PD0: R387.2 (-); also elsewhere on the board
FDC_PD1: R388.2 (-); also elsewhere on the board
FDC_PD2: R389.2 (-); also elsewhere on the board
FDC_PD3: R390.2 (-); also elsewhere on the board
FDC_PD4: R391.2 (-); also elsewhere on the board
FDC_PD5: R392.2 (-); also elsewhere on the board
FDC_PD6: R393.2 (-); also elsewhere on the board
FDC_PD7: R394.2 (-); also elsewhere on the board
FDC_RDATA#: R379.2; also elsewhere on the board
FDC_RI1#: J18.5 (RI1#), R409.1; also elsewhere on the board
FDC_RI2#: R380.1; also elsewhere on the board
FDC_RTS1#: R417.1, U56.5; also elsewhere on the board
FDC_RXD1: J18.10 (RXD1), R412.1; also elsewhere on the board
FDC_TRK0#: R420.2; also elsewhere on the board
FDC_TXD1: R418.1, U56.2; also elsewhere on the board
FDC_TXD2_EN: R402.1, U72.6, U73.5
FDC_UART1_EN: U56.1, U56.4, U56.10; also elsewhere on the board
FDC_WRTPRT#: R421.1; also elsewhere on the board
FDD_Bowman: R414.2; also elsewhere on the board
GND: C255.2 (-), C256.2 (-), C257.2 (-), C258.2 (-), C259.1 (+), C260.1 (+), C261.1 (+), C262.2 (-), C263.1 (+), C265.1 (+), C266.1 (+), C267.2 (-), C268.2 (-), C269.2 (-), C270.1 (+), C271.2 (-), C273.1 (+), C274.1 (+), C275.2 (-), C276.1 (+), C277.1 (+), C278.2 (-), C280.2 (-), C281.1 (+), C282.2 (-), C283.2 (-), D55.1 (A), D56.1 (A), D58.1 (A), D59.1 (A), D60.1 (A), J18.1 (GND), J18.13 (GND), J18.14 (GND), J18.26 (GND), Q43.2 (E), R376.1, R377.1, R413.2 (-), R419.2 (-), U36.4 (GND), U56.7 (GND), U58.4, U58.5, U58.7 (GND), U72.7 (GND), U73.4 (GND), U74.4 (GND), U75.2 (GND), U76.3 (GND); also elsewhere on the board
KB_INIT1: EM5.5, RA5.5 (R4.2); also elsewhere on the board
KB_INIT2: EM5.6, RA5.6 (R3.2); also elsewhere on the board
KB_INIT3: EM5.8, RA5.8 (R1.2); also elsewhere on the board
KB_INIT4: EM5.7, RA5.7 (R2.2); also elsewhere on the board
KB_SPKUP_DN: D54.3 (A); also elsewhere on the board
KB_SRDY#_shift: R381.1; also elsewhere on the board
MN192_VSEN#: J18.16 (VSEN#); also elsewhere on the board
MN195_U1RD#: J18.3 (U1RD#); also elsewhere on the board
Modem_Audio_Out: C279.1 (+); also elsewhere on the board
Modem_VSDA#: J18.17 (VSDA#), R403.1; also elsewhere on the board
unnamed: C256.1 (+), J17.4 (5V), L17.2
unnamed: C257.1 (+), J17.7 (PS2_Pluto), L18.2
unnamed: C258.1 (+), EM5.1, J17.5 (KB_INIT3)
unnamed: C262.1 (+), EM5.2, J17.3 (KB_INIT4)
unnamed: C263.2 (-), EM5.3, J17.6 (KB_INIT2)
unnamed: C264.1 (+), Q40.1 (B), R381.2
unnamed: C264.2 (-), F3.2, Q40.2 (C)
unnamed: C265.2 (-), EM5.4, J17.2 (KB_INIT1)
unnamed: C272.1 (+), Q41.1 (B), R395.1, R396.2
unnamed: C273.2 (-), C275.1 (+), R397.1, U75.6 (IRDA_Supply)
unnamed: C274.2 (-), R401.1, U75.8 (IRDA_LED_A)
unnamed: C276.2 (-), U75.5 (Daylight_Cancellation)
unnamed: C277.2 (-), U75.3 (PIN_Bypass)
unnamed: C278.1 (+), U73.1, U75.1 (IRDA_RXA)
unnamed: C279.2 (-), J18.18 (VPCK#)
unnamed: C283.1 (+), D57.1 (A), D57.3 (A), R404.1, U76.2
unnamed: D57.2 (K), R404.2, U73.3
unnamed: J17.1 (GND), R377.2
unnamed: J17.8 (GND), R376.2
unnamed: J18.6 (DRT1#), U56.8
unnamed: J18.9 (RTS1#), U56.6
unnamed: J18.11 (TXD1), U56.3
unnamed: F4.1, Q41.3 (E), R395.2
unnamed: Q42.3 (C), R397.2
unnamed: Q43.1 (B), R400.2
unnamed: Q43.3 (C), R398.1
unnamed: Q44.1 (B), R399.1
unnamed: Q44.2 (C), R401.2
unnamed: R396.1, R398.2
unnamed: R400.1, U36.2
unnamed: U36.6, U58.3, U72.1, U72.13
unnamed: U72.9, U73.7
unnamed: U73.2, U76.4
unnamed: R402.2, U75.7 (IRDA_TXD)
PNET1: D55.2 (K), D56.2 (K), D58.2 (K), D59.2 (K), D60.2 (K), R384.1, R403.2, U56.14 (VCC); also elsewhere on the board
PNET2: C255.1 (+), C268.1 (+), C269.1 (+), C282.1 (+), R378.1, U73.8 (VCC), U76.5 (VCC); also elsewhere on the board
PNET4: D52.1 (K), D53.1 (K); also elsewhere on the board
PNET5: C259.2 (-), C261.2 (-), C270.2 (-), C271.1 (+), F4.2, Q40.3 (E), Q42.2 (E), Q44.3 (E), R379.1, R380.2, R382.1, R383.1, R385.2, R386.1, R405.1, R407.1, R416.2, R417.2, R418.2, R420.1, R421.2, R422.1, R424.1, U36.8 (VCC), U58.14 (VCC), U72.14 (VCC), U74.8 (VCC); also elsewhere on the board
PNET7: R414.1, R415.1, R423.1; also elsewhere on the board
PS2_L1_Pluto: L18.1, R384.2; also elsewhere on the board
PWRGD_shift_buff: R406.2, U58.1; also elsewhere on the board
Pluto_Dock_IO1: R419.1 (+), R423.2; also elsewhere on the board
Pluto_Dock_IO2: R413.1 (+), R415.2; also elsewhere on the board
Pluto_IRDA_OUT: U73.6; also elsewhere on the board
Pluto_Switched_PNET5: C280.1 (+), J18.12 (PNET5_Pluto), J18.15 (PNET5_Pluto), R408.2, R409.2, R410.2, R411.2, R412.2; also elsewhere on the board
U71_OR1_IN2: U58.2; also elsewhere on the board
VCC: C281.2 (-), J18.2 (VCC), J18.25 (VCC); also elsewhere on the board
VGA_Blue: D60.3 (COM); also elsewhere on the board
VGA_Green: D59.3 (COM); also elsewhere on the board
VGA_HSync: D55.3 (COM); also elsewhere on the board
VGA_Red: D58.3 (COM); also elsewhere on the board
VGA_VSync: D56.3 (COM); also elsewhere on the board
YellowWire1_2: R406.1; also elsewhere on the board
YellowWire2_1: D54.1 (A); also elsewhere on the board
YellowWire2_3: D54.2 (K); also elsewhere on the board

Notes on the sheet:
Enables all external PS/2 devices; PS/2 conn on PC110 and dock

Schematic: Clock.kicad_sch, PC110

Parts:
C1, C13: 100nF; C_0402_1005Metric
C2, C11: 150nF; C_0402_1005Metric
C3, C9: 1nF; C_0402_1005Metric
C4, C5, C6: DNP; C_0402_1005Metric; not fitted
C7: 10uF; C_1206_3216Metric
C8: 330nF; C_0603_1608Metric
C10: 220pF; C_0402_1005Metric
C12: 10nF; C_0603_1608Metric
D1: DNP; 3D; not fitted
Q1: 6D; SOT-23
R1, R3, R4, R7, R8, R9, R11: 33; R_0402_1005Metric
R2: 47; R_0402_1005Metric
R5: 56; R_0402_1005Metric
R6: DNP; R_0402_1005Metric; not fitted
R10: 10; R_0805_2012Metric
R12: 4.7k; R_0402_1005Metric
R13: 470k; R_0402_1005Metric
R14: 0; R_0402_1005Metric
U1: SN74LV02; TSSOP-14_4.4x5mm_P0.65mm
U2: SN74LVT125; TSSOP-14_4.4x5mm_P0.65mm
U3: AV9154A-27; SOIC-16W
U4: 8C01; SOT-23-5
X1: 59G3482; XTAL-6

Connections:
Bowman_CLK: R4.2; also elsewhere on the board
Chipset_2XCPU_CLK: R11.2; also elsewhere on the board
Chipset_CLK: R8.1; also elsewhere on the board
ESS_CLK: R6.2; also elsewhere on the board
FDC_CLK: R3.2; also elsewhere on the board
GND: C1.1 (+), C2.1 (+), C3.1 (+), C4.1 (+), C5.2 (-), C7.1 (+), C8.1 (+), C9.1 (+), C10.1 (+), C11.1 (+), C12.2, C13.2, R12.2, R13.2, U1.7 (GND), U2.1, U2.4, U2.7 (GND), U2.10, U2.13, U3.5 (GND), U3.8 (AGND), U3.12 (GND), U3.15 (FS1), U4.3 (GND), X1.3; also elsewhere on the board
unnamed: C4.2 (-), C6.2 (-), U3.2 (X2), X1.2
unnamed: C5.1 (+), C6.1 (+), U3.3 (X1), X1.1
unnamed: C7.2 (-), C8.2 (-), C9.2 (-), C10.2 (-), R10.2, U3.4 (VCC), U3.13 (VCC)
unnamed: C11.2 (-), D1.2 (K), Q1.3 (C), R10.1, R12.1, R14.1, U3.10 (FS2), U3.16 (FS0)
unnamed: Q1.1 (B), U1.13
unnamed: R1.1, U2.2, U2.5, U2.12
unnamed: R2.1, U2.9
unnamed: R3.1, R4.1, U2.8
unnamed: R5.1, R6.1, U2.11
unnamed: R7.2, R8.2, U2.6
unnamed: R9.2, U2.3
unnamed: R11.1, U3.14 (3XCPUCLK)
unnamed: R1.2, U3.11 (14.318MHz)
unnamed: R2.2, U3.6 (24MHz)
unnamed: R13.1, U3.9 (OE), U4.1 (OUT)
unnamed: C12.1, D1.3 (A), U4.5 (CD)
unnamed: C13.1, D1.1 (A), R14.2, U4.2 (VDD)
PNET1: C1.2 (-), C2.2 (-), C3.2 (-), Q1.2 (E), U1.14 (VCC), U2.14 (VCC); also elsewhere on the board
PWRGD: U1.12; also elsewhere on the board
Pluto_CLK: R7.1; also elsewhere on the board
RESET: U1.11; also elsewhere on the board
VGA_CLK: R9.1; also elsewhere on the board
YMF_CLK: R5.2; also elsewhere on the board
