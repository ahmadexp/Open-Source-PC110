# Repository ahmadexp/Open-Source-PC110 (continued)

## KiCad design Mods/PC110-ITX/PC110.kicad_pcb (continued)

Schematic: VGA.kicad_sch, PC110

Parts:
C5, C17, C26, C31, C32, C39, C42: 150nF; C_0402_1005Metric
C30, C36, C206, C210: 10uF; C_1206_3216Metric
C34, C37, C38, C40, C43, C188: 1nF; C_0402_1005Metric
C41: 120nF; C_0402_1005Metric
C45: 270nF; C_0603_1608Metric
C48: 330nF; C_0402_1005Metric
C156, C172, C189: 100nF; C_0402_1005Metric
C169, C171, C173, C174, C175, C177, C178, C180, C181, C182, C183, C184, C185, C186, C187, C191, C192, C193, C194, C195, C196: 56pF; C_0402_1005Metric
C176: 470nF; C_0603_1608Metric
D2: K; SOT-416L
D36: 71; D_0603_1608Metric
EM1, EM2, EM3, EM4: R-array
J2: LCD_connector
L3, L6, L11, L14, L16, L17, L18: 1.5uH; L_0603_1608Metric
L9, L10: 300nH; L_0805_2012Metric
Q1: IS6; SOT-23
Q2: 8C; SOT-416
R1, R2, R5, R6, R7, R10, R11, R13, R15, R18, R19, R22, R61, R229, R233, R259, R269: 470k; R_0402_1005Metric
R3: 131k; R_0402_1005Metric
R9, R263, R265, R270, R279: 4.7k; R_0402_1005Metric
R12: 182k; R_0402_1005Metric
R14, R17, R20: 10; R_0402_1005Metric
R16, R21, R51, R58: 0; R_0402_1005Metric
R46, R53, R255: 33; R_0402_1005Metric
R66: 270; R_0402_1005Metric
R234: 100k; R_0402_1005Metric
R236: 470; R_0402_1005Metric
R264, R267, R273: 150; R_0805_2012Metric
U8: 51W4260ATT7; GRAMchip
U51: EIAJ160

Connections:
/VGA Controller/LCD_24: C174.1 (+), EM4.1, J2.24
/VGA Controller/LCD_B0: C173.1 (+), EM1.4, J2.8
/VGA Controller/LCD_B1: C183.1 (+), EM1.3, J2.9
/VGA Controller/LCD_B2: C194.1 (+), EM1.2, J2.10
/VGA Controller/LCD_B3: C181.1 (+), EM1.1, J2.11
/VGA Controller/LCD_B4: C180.1 (+), EM3.4, J2.17
/VGA Controller/LCD_G0: C182.1 (+), EM3.3, J2.18
/VGA Controller/LCD_G1: C187.1 (+), EM3.2, J2.19
/VGA Controller/LCD_G2: C186.1 (+), EM3.1, J2.20
/VGA Controller/LCD_G3: C191.1 (+), EM2.4, J2.12
/VGA Controller/LCD_G4: C184.1 (+), EM2.3, J2.13
/VGA Controller/LCD_R0: C185.1 (+), EM2.2, J2.14
/VGA Controller/LCD_R1: C169.1 (+), EM2.1, J2.15
/VGA Controller/LCD_R2: C196.1 (+), EM4.4, J2.21
/VGA Controller/LCD_R3: C175.1 (+), EM4.3, J2.22
/VGA Controller/LCD_R4: C178.1 (+), EM4.2, J2.23
CPU_A2: U51.135 (A2); also elsewhere on the board
CPU_A3: U51.136 (A3); also elsewhere on the board
CPU_A4: U51.137 (A4); also elsewhere on the board
CPU_A5: U51.138 (A5); also elsewhere on the board
CPU_A6: U51.140 (A6); also elsewhere on the board
CPU_A7: U51.141 (A7); also elsewhere on the board
CPU_A8: U51.143 (A8); also elsewhere on the board
CPU_A9: U51.144 (A9); also elsewhere on the board
CPU_A10: U51.145 (A10); also elsewhere on the board
CPU_A11: U51.146 (A11); also elsewhere on the board
CPU_A12: U51.147 (A12); also elsewhere on the board
CPU_A13: U51.148 (A13); also elsewhere on the board
CPU_A14: U51.149 (A14); also elsewhere on the board
CPU_A15: U51.150 (A15); also elsewhere on the board
CPU_A16: U51.151 (A16); also elsewhere on the board
CPU_A17: U51.152 (A17); also elsewhere on the board
CPU_A18: U51.153 (A18); also elsewhere on the board
CPU_A19: U51.1 (A19); also elsewhere on the board
CPU_A20: U51.2 (A20); also elsewhere on the board
CPU_A21: U51.3 (A21); also elsewhere on the board
CPU_A22: U51.4 (A22); also elsewhere on the board
CPU_A23: U51.5 (A23); also elsewhere on the board
CPU_ADS#: U51.9 (ADS#); also elsewhere on the board
CPU_BE0#: U51.133 (BE0#); also elsewhere on the board
CPU_BE1#: U51.8 (BE1#); also elsewhere on the board
CPU_BE2#: U51.134 (BE2#); also elsewhere on the board
CPU_BE3#: U51.7 (BE3#); also elsewhere on the board
CPU_BS16#: U51.40 (BS16#); also elsewhere on the board
CPU_D0: U51.31 (D0); also elsewhere on the board
CPU_D1: U51.30 (D1); also elsewhere on the board
CPU_D2: U51.28 (D2); also elsewhere on the board
CPU_D3: U51.27 (D3); also elsewhere on the board
CPU_D4: U51.26 (D4); also elsewhere on the board
CPU_D5: U51.25 (D5); also elsewhere on the board
CPU_D6: U51.24 (D6); also elsewhere on the board
CPU_D7: U51.23 (D7); also elsewhere on the board
CPU_D8: U51.21 (D8); also elsewhere on the board
CPU_D9: U51.20 (D9); also elsewhere on the board
CPU_D10: U51.18 (D10); also elsewhere on the board
CPU_D11: U51.17 (D11); also elsewhere on the board
CPU_D12: U51.16 (D12); also elsewhere on the board
CPU_D13: U51.15 (D13); also elsewhere on the board
CPU_D14: U51.14 (D14); also elsewhere on the board
CPU_D15: U51.13 (D15); also elsewhere on the board
CPU_D16: U51.82 (D16); also elsewhere on the board
CPU_D17: U51.84 (D17); also elsewhere on the board
CPU_D18: U51.85 (D18); also elsewhere on the board
CPU_D19: U51.87 (D19); also elsewhere on the board
CPU_D20: U51.88 (D20); also elsewhere on the board
CPU_D21: U51.89 (D21); also elsewhere on the board
CPU_D22: U51.90 (D22); also elsewhere on the board
CPU_D23: U51.91 (D23); also elsewhere on the board
CPU_D24: U51.92 (D24); also elsewhere on the board
CPU_D25: U51.93 (D25); also elsewhere on the board
CPU_D26: U51.94 (D26); also elsewhere on the board
CPU_D27: U51.95 (D27); also elsewhere on the board
CPU_D28: U51.96 (D28); also elsewhere on the board
CPU_D29: U51.97 (D29); also elsewhere on the board
CPU_D30: U51.98 (D30); also elsewhere on the board
CPU_D31: U51.99 (D31); also elsewhere on the board
CPU_LDEV#: U51.36 (LDEV#); also elsewhere on the board
CPU_MIO#: U51.10 (MIO#); also elsewhere on the board
CPU_RDY#: U51.34 (MEMW#), U51.37 (IOWR#); also elsewhere on the board
CPU_WR#: U51.33 (MEMR#); also elsewhere on the board
Chipset_32KHz: U51.109 (32kHz); also elsewhere on the board
Chipset_CPU_CLK: R255.1; also elsewhere on the board
F65_ENAVEE: U51.47 (ENAVEE); also elsewhere on the board
GND: C5.2 (-), C17.2 (-), C26.2 (-), C30.1 (+), C31.1 (+), C32.2 (-), C34.2 (-), C36.1 (+), C37.2 (-), C38.2 (-), C39.2 (-), C40.2 (-), C41.2 (-), C42.1 (+), C43.2 (-), C45.2 (-), C48.2 (-), C156.1 (+), C169.2 (-), C171.2 (-), C172.1 (+), C173.2 (-), C174.2 (-), C175.2 (-), C176.2 (-), C177.1 (+), C178.2 (-), C180.2 (-), C181.2 (-), C182.2 (-), C183.2 (-), C184.2 (-), C185.2 (-), C186.2 (-), C187.2 (-), C188.2 (-), C189.1 (+), C191.2 (-), C192.2 (-), C193.2 (-), C194.2 (-), C195.1 (+), C196.2 (-), C206.1 (+), C210.1 (+), D36.2 (A), L10.2 (-), Q2.2 (E), R1.1, R2.1, R5.1, R6.1, R7.1, R10.1, R11.2, R13.1, R15.2, R18.2, R19.1, R22.1, R61.1, R66.1, R233.2, R259.2, R263.2, R264.2, R265.2, R267.2, R269.2, R270.2, R273.2, R279.2, U8.21 (GND), U8.27 (OE#), U8.35 (GND), U8.40 (GND), U51.12 (GND), U51.22 (GND), U51.32 (GND), U51.42 (GND), U51.49 (GND), U51.59 (GND), U51.77 (GND), U51.83 (GND), U51.115 (GND), U51.142 (GND), U51.154 (GND), U51.160 (GND); also elsewhere on the board
LCD_NC_L11: L16.2 (-), R229.1; also elsewhere on the board
LCD_STNDBY#: U51.11 (STNDBY#); also elsewhere on the board
LCD_VAA: J2.3; also elsewhere on the board
unnamed: C30.2 (-), C36.2 (-), C48.1 (+), L3.2 (-), U51.158 (VCC)
unnamed: C171.1 (+), J2.6, L16.1 (+)
unnamed: C176.1 (+), C188.1 (+), J2.4, L9.1 (+), R234.2
unnamed: C177.2 (-), J2.27, L18.1 (+)
unnamed: C189.2 (-), J2.2, L14.1 (+)
unnamed: C192.1 (+), J2.26, L11.2 (-)
unnamed: C193.1 (+), J2.5, R234.1
unnamed: C195.2 (-), J2.29, L17.2 (-)
unnamed: C45.1 (+), C206.2 (-), C210.2 (-), L6.1 (+), U51.157 (VCC)
unnamed: D2.2 (A), R3.1
unnamed: D2.1 (K), R12.2, U51.48 (ENAVDD)
unnamed: D2.3 (common), Q2.1 (B), R12.1
unnamed: D36.1 (K), L14.2 (-), R236.2
unnamed: J2.1, J2.7, J2.16, J2.25, J2.28, J2.30, L10.1 (+)
unnamed: L9.2 (-), Q1.3 (C), R3.2, R236.1
unnamed: L11.1 (+), R14.2
unnamed: L17.1 (+), R20.2
unnamed: L18.2 (-), R17.2
unnamed: Q1.1 (B), R9.2
unnamed: Q2.3 (C), R9.1
unnamed: R58.2, U8.29 (LCAS#)
unnamed: R21.1, U8.14 (RAS#)
unnamed: R51.2, U8.28 (UCAS#)
unnamed: R16.1, U8.13 (WE#)
unnamed: R51.1, U51.112 (CASAH#)
unnamed: R58.1, U51.113 (CASAL#)
unnamed: R255.2, U51.35 (CCLK)
unnamed: R14.1, U51.53 (FLM)
unnamed: R53.2, U51.51 (HSYNC)
unnamed: R11.1, U8.2 (DQ0), U51.114 (IO0)
unnamed: R1.2, U8.3 (DQ1), U51.116 (IO1)
unnamed: R10.2, U8.4 (DQ2), U51.117 (IO2)
unnamed: R6.2, U8.5 (DQ3), U51.119 (IO3)
unnamed: R7.2, U8.7 (DQ4), U51.120 (IO4)
unnamed: R13.2, U8.8 (DQ5), U51.121 (IO5)
unnamed: R5.2, U8.9 (DQ6), U51.122 (IO6)
unnamed: R2.2, U8.10 (DQ7), U51.123 (IO7)
unnamed: R269.1, U8.31 (DQ8), U51.124 (IO8)
unnamed: R259.1, U8.32 (DQ9), U51.125 (IO9)
unnamed: R61.2, U8.33 (DQ10), U51.126 (IO10)
unnamed: R18.1, U8.34 (DQ11), U51.127 (IO11)
unnamed: R15.1, U8.36 (DQ12), U51.128 (IO12)
unnamed: R22.2, U8.37 (DQ13), U51.129 (IO13)
unnamed: R233.1, U8.38 (DQ14), U51.130 (IO14)
unnamed: R19.2, U8.39 (DQ15), U51.131 (IO15)
unnamed: R17.1, U51.54 (LP)
unnamed: R263.1, U51.38 (OEL#)
unnamed: EM1.5, U51.57 (P0)
unnamed: EM1.6, U51.58 (P1)
unnamed: EM1.7, U51.60 (P2)
unnamed: EM1.8, U51.61 (P3)
unnamed: EM3.5, U51.63 (P4)
unnamed: EM3.6, U51.64 (P5)
unnamed: EM3.7, U51.65 (P6)
unnamed: EM3.8, U51.66 (P7)
unnamed: EM2.5, U51.67 (P8)
unnamed: EM2.6, U51.68 (P9)
unnamed: EM2.7, U51.69 (P10)
unnamed: EM2.8, U51.70 (P11)
unnamed: EM4.5, U51.71 (P12)
unnamed: EM4.6, U51.72 (P13)
unnamed: EM4.7, U51.73 (P14)
unnamed: EM4.8, U51.74 (P15)
unnamed: R21.2, U51.110 (RASA#)
unnamed: R66.2, U51.41 (RSET)
unnamed: R265.1, U8.16 (A0), U51.100 (SA0)
unnamed: U8.17 (A1), U51.101 (SA1)
unnamed: U8.18 (A2), U51.102 (SA2)
unnamed: U8.19 (A3), U51.103 (SA3)
unnamed: U8.22 (A4), U51.104 (SA4)
unnamed: R270.1, U8.23 (A5), U51.105 (SA5)
unnamed: U8.24 (A6), U51.106 (SA6)
unnamed: U8.25 (A7), U51.107 (SA7)
unnamed: R279.1, U8.26 (A8), U51.108 (SA8)
unnamed: R20.1, U51.56 (SHFCLK)
unnamed: R46.2, U51.50 (VSYNC)
unnamed: R16.2, U51.111 (WEA#)
PNET1: C5.1 (+), C17.1 (+), C26.1 (+), C31.2 (-), C32.1 (+), C34.1 (+), C37.1 (+), C38.1 (+), C39.1 (+), C40.1 (+), C41.1 (+), C42.2 (-), C43.1 (+), C156.2 (-), C172.2 (-), L3.1 (+), L6.2 (-), R229.2, U8.1 (VCC), U8.6 (VCC), U8.20 (VCC), U51.19 (VCC), U51.29 (VCC), U51.45 (VCC), U51.52 (VCC), U51.62 (VCC), U51.86 (VCC), U51.118 (VCC), U51.132 (VCC), U51.139 (VCC); also elsewhere on the board
PNET5: Q1.2 (E); also elsewhere on the board
RESET: U51.159 (RESET); also elsewhere on the board
VGA_ADDHI: U51.6 (ADDHI); also elsewhere on the board
VGA_Blue: R264.1, U51.43 (VGA_Blue); also elsewhere on the board
VGA_CLK: U51.155 (XTALI); also elsewhere on the board
VGA_Green: R273.1, U51.44 (VGA_Green); also elsewhere on the board
VGA_HSync: R53.1; also elsewhere on the board
VGA_Red: R267.1, U51.46 (VGA_Red); also elsewhere on the board
VGA_VSync: R46.1; also elsewhere on the board

Schematic: Super_IO.kicad_sch, PC110

Parts:
C83, C84, C120: 100nF; C_0402_1005Metric
C244: 120nF; C_0402_1005Metric
C247: 1nF; C_0402_1005Metric
D24, D25: 3D
R118, R310: 100k; R_0402_1005Metric
R132, R133, R137: 2k; R_0402_1005Metric
R136, R138, R140, R141, R142, R319: 1k; R_0402_1005Metric
R143: 10k; R_0402_1005Metric
R314, R315: 470k; R_0402_1005Metric
U22: FDC37C665IR; FDC
U23: EA; SOT-353
U25: E4; SOT-353

Connections:
AEN: U22.44 (AEN); also elsewhere on the board
Chipset_FDC_TC: U22.33 (TC); also elsewhere on the board
FCS_IOCHRDY: U22.98 (IOCHRDY); also elsewhere on the board
FDC_ACK#: R136.1, U22.60 (ACK#); also elsewhere on the board
FDC_AUTOFD#: R141.1, U22.74 (AUTOFD#); also elsewhere on the board
FDC_BUSY: R143.2, U22.59 (BUSY); also elsewhere on the board
FDC_CLK: U22.18 (X1/CLK1); also elsewhere on the board
FDC_CTS1#: U22.80 (CTS1#); also elsewhere on the board
FDC_CTS2#: U22.90 (CTS2#); also elsewhere on the board
FDC_DACK#: R118.1, U22.34 (DACK#); also elsewhere on the board
FDC_DCD1#: U22.83 (DCD1#); also elsewhere on the board
FDC_DCD2#: U22.85 (DCD2#); also elsewhere on the board
FDC_DIR#: U22.5 (DIR#); also elsewhere on the board
FDC_DRATE0: U22.17 (DRATE0); also elsewhere on the board
FDC_DRATE1: U22.16 (DRATE1); also elsewhere on the board
FDC_DS3: U22.95 (A10); also elsewhere on the board
FDC_DSKCHG#: U22.15 (DSKCHG#); also elsewhere on the board
FDC_DSR1: U22.78 (DSR1); also elsewhere on the board
FDC_DSR2#: U22.88 (DSR2#); also elsewhere on the board
FDC_DTR1#: U22.81 (DTR1#); also elsewhere on the board
FDC_DTR2#: U22.91 (DTR2#); also elsewhere on the board
FDC_ERROR#: R142.1, U22.73 (ERROR#); also elsewhere on the board
FDC_FDRQ: U22.50 (FDRQ); also elsewhere on the board
FDC_FINTR: U22.38 (FINTR); also elsewhere on the board
FDC_HDCS0#: U22.23 (HDCS0#); also elsewhere on the board
FDC_HDCS1#: U22.24 (HDCS1#); also elsewhere on the board
FDC_HDSEL#: U22.9 (HDSEL#); also elsewhere on the board
FDC_IDE7: U22.20 (IDED7); also elsewhere on the board
FDC_INIT#: R133.1, U22.72 (INIT#); also elsewhere on the board
FDC_IOW: U23.2; also elsewhere on the board
FDC_IRRX_RXD2: R315.1, U22.86 (IRRX/RXD2); also elsewhere on the board
FDC_IRTX_TXD2: U22.87 (IRTX/TXD2); also elsewhere on the board
FDC_MTR2#: R310.1, U22.94 (MTR2#); also elsewhere on the board
FDC_MTR3#: U22.97 (MTR3#); also elsewhere on the board
FDC_PD0: U22.69 (PD0); also elsewhere on the board
FDC_PD1: U22.68 (PD1); also elsewhere on the board
FDC_PD2: U22.67 (PD2); also elsewhere on the board
FDC_PD3: U22.66 (PD3); also elsewhere on the board
FDC_PD4: U22.64 (PD4); also elsewhere on the board
FDC_PD5: U22.63 (PD5); also elsewhere on the board
FDC_PD6: U22.62 (PD6); also elsewhere on the board
FDC_PD7: U22.61 (PD7); also elsewhere on the board
FDC_PE: R138.1, U22.58 (PE); also elsewhere on the board
FDC_RDATA#: U22.14 (RDATA#); also elsewhere on the board
FDC_RI1#: U22.82 (RI1#); also elsewhere on the board
FDC_RI2#: U22.84 (RI2#); also elsewhere on the board
FDC_RTS1#: U22.79 (RTS1#); also elsewhere on the board
FDC_RTS2#: U22.89 (RTS2#); also elsewhere on the board
FDC_RXD1: U22.76 (RXD1); also elsewhere on the board
FDC_SLCT: R140.2, U22.57 (SLCT); also elsewhere on the board
FDC_SLCTIN#: R132.1, U22.71 (SLCTIN#); also elsewhere on the board
FDC_STEP#: U22.6 (STEP#); also elsewhere on the board
FDC_STROBE#: R137.1, U22.75 (STROBE#); also elsewhere on the board
FDC_TRK0#: U22.11 (TRK0#); also elsewhere on the board
FDC_TXD1: U22.77 (TXD1); also elsewhere on the board
FDC_WDATA#: U22.7 (WDATA#); also elsewhere on the board
FDC_WGATE#: U22.8 (WGATE#); also elsewhere on the board
FDC_WRTPRT#: U22.12 (WRTPRT#); also elsewhere on the board
FDD_DRSEL: U22.2 (DS0#); also elsewhere on the board
FDD_INDEX#: U22.10 (INDEX#); also elsewhere on the board
FDD_MOTEN: U22.100 (MTR0#); also elsewhere on the board
GND: C83.2 (-), C84.2 (-), C120.2 (-), C244.1, C247.2, R314.2, U22.4 (VSS), U22.45 (VSS), U22.65 (VSS), U22.93 (VSS), U23.3 (GND), U25.3 (GND); also elsewhere on the board
IOCS16#: R319.2, U22.25 (IOCS16#); also elsewhere on the board
IOR#: U22.42 (IOR#); also elsewhere on the board
IOW#: U25.2; also elsewhere on the board
IRQ3: U22.35 (IRQ3); also elsewhere on the board
IRQ4: U22.36 (IRQ4); also elsewhere on the board
IRQ5: U22.92 (DRV2/ADRx/PINTR2); also elsewhere on the board
IRQ7: U22.37 (PINTR); also elsewhere on the board
unnamed: D24.2 (K), R132.2, R136.2, R137.2, R141.2
unnamed: D25.2 (K), R133.2, R138.2, R140.1, R142.2, R143.1
unnamed: U22.43 (IOW#), U25.4
unnamed: U23.4, U25.1
PNET1: C83.1 (+), C247.1, R118.2, R310.2, U22.13 (VCC), U22.70 (VCC), U23.5 (VCC), U25.5 (VCC); also elsewhere on the board
PNET5: C84.1 (+), C120.1 (+), C244.2, D24.1 (A), D24.3 (A), D25.1 (A), D25.3 (A), R315.2, U22.96 (VIO); also elsewhere on the board
PNET7: R319.1; also elsewhere on the board
PWRGD: R314.1, U22.56 (PWRGD); also elsewhere on the board
RESET: U22.55 (RESET); also elsewhere on the board
SA0: U22.26 (A0); also elsewhere on the board
SA1: U22.27 (A1); also elsewhere on the board
SA2: U22.28 (A2); also elsewhere on the board
SA3: U22.29 (A3); also elsewhere on the board
SA4: U22.30 (A4); also elsewhere on the board
SA5: U22.31 (A5); also elsewhere on the board
SA6: U22.32 (A6); also elsewhere on the board
SA7: U22.39 (A7); also elsewhere on the board
SA8: U22.40 (A8); also elsewhere on the board
SA9: U22.41 (A9); also elsewhere on the board
SD0: U22.46 (D0); also elsewhere on the board
SD1: U22.47 (D1); also elsewhere on the board
SD2: U22.48 (D2); also elsewhere on the board
SD3: U22.49 (D3); also elsewhere on the board
SD4: U22.51 (D4); also elsewhere on the board
SD5: U22.52 (D5); also elsewhere on the board
SD6: U22.53 (D6); also elsewhere on the board
SD7: U22.54 (D7); also elsewhere on the board

Notes on the sheet:
Device_Address_BUS
Device_Data_BUS

Schematic: Storage.kicad_sch, PC110

Parts:
C94, C129, C133, C141, C146, C236, C241, C263: 100nF; C_0402_1005Metric
C131: 10nF; C_0603_1608Metric
C132: 100nF; C_0603_1608Metric
C134: 150nF; C_0603_1608Metric
C142, C143, C271, C272: 150nF; C_0402_1005Metric
C144, C145: 100pF; C_0402_1005Metric
C262: 1.5uF; C_0805_2012Metric
C266: 180pF; C_0402_1005Metric
C269: 220pF; C_0402_1005Metric
F4: 0.5A; Fuse_1206_3216Metric
J11: CF-card
Q37: BH RT; SOT-89-3
R131, R184: DNP; R_0402_1005Metric; not fitted
R134, R365: 10k; R_0402_1005Metric
R145, R290, R296, R298, R301: DNP; R_0402_1005Metric
R161, R173, R360, R361: 470k; R_0402_1005Metric
R292: DNP; R_0805_2012Metric
R295, R299, R366, R367: 0; R_0402_1005Metric
R300: 0; R_0805_2012Metric
R362, R371: 2k; R_0402_1005Metric
R368: 1.5k; R_0402_1005Metric
R369: 22k; R_0402_1005Metric
R373, R374, R375, R376, R377, R378, R380, R381: 4.7k; R_0402_1005Metric
U27: AT29LV512-12TU; Flash-32
U41: SDLB-4; SanDisk
U42: SC414281PU4; QFN-100
U56: SN74LV32; TSSOP-14_4.4x5mm_P0.65mm
U65: E4; SOT-353
U68: SN74LV08; TSSOP-14_4.4x5mm_P0.65mm

Connections:
CF_CD1_Pluto: J11.2 (CD1#), R173.2; also elsewhere on the board
CF_CD2_Pluto: J11.49 (CD2#), R161.1; also elsewhere on the board
FCS_BVD1: J11.42 (BVD1), U42.50 (BVD1)
FCS_BVD2: J11.40 (BVD2), U42.49 (BVD2)
FCS_IOCHRDY: J11.34 (IOCHRDY), U42.47 (WAIT); also elsewhere on the board
FCS_RESET: J11.32 (RESET), R184.1, U42.36 (RESET); also elsewhere on the board
FDC_HDCS0#: R366.2, U68.1; also elsewhere on the board
FDC_HDCS1#: R367.2, U68.2; also elsewhere on the board
FDC_IDE7: J11.11 (SD7), R369.2, U42.13 (HD7); also elsewhere on the board
GND: C94.2, C129.2 (-), C131.2, C132.2, C133.2, C134.1, C144.1, C145.1, C236.2, C241.1, C262.1, C263.1, C269.1, C271.2, C272.2 (-), J11.1 (GND), J11.15 (GND), J11.16 (GND), J11.17 (GND), J11.19 (GND), J11.21 (GND), J11.23 (GND), J11.27 (GND), J11.29 (GND), J11.31 (GND), J11.33 (GND), J11.50 (GND), R131.1, R145.1, R184.2, U27.24 (GND), U41.3 (GND), U41.6 (GND), U41.8 (GND), U41.12 (GND), U41.15 (GND), U41.16 (GND), U41.18 (GND), U41.19 (GND), U42.10 (GND), U42.20 (GND), U42.23 (CSEL), U42.24 (SA10), U42.25 (SA9), U42.26 (SA8), U42.27 (SA7), U42.28 (SA6), U42.29 (SA5), U42.30 (SA4), U42.31 (SA3), U42.32 (GND), U42.40 (OE), U42.44 (GND), U42.51 (WPROTCT), U42.61 (GND), U42.70 (GND), U42.82 (GND), U42.94 (GND), U56.7 (GND), U56.9, U56.10, U56.12, U56.13, U65.2, U65.3 (GND), U68.4, U68.5, U68.7 (GND), U68.9, U68.10, U68.12, U68.13; also elsewhere on the board
IOCS16#: J11.47 (IOCS16#), U42.52 (IO16); also elsewhere on the board
IOR#: R295.2, R296.1, U56.1; also elsewhere on the board
IOW#: R298.2, R299.2, U56.4; also elsewhere on the board
IRQ14: J11.24 (IRQ14), R365.1, U42.46 (RDY); also elsewhere on the board
unnamed: C129.1 (+), C272.1 (+), F4.2, J11.25 (VCC), J11.26 (VCC)
unnamed: C266.1, C269.2
unnamed: C266.2, R362.2
unnamed: J11.13 (CE1#), R361.1, R366.1, U42.37 (CE1)
unnamed: J11.14 (CE2#), R360.1, R367.1, U42.39 (CE2)
unnamed: J11.28 (CSEL#), R145.2
unnamed: J11.18 (IOR#), R295.1, R301.2
unnamed: J11.20 (IOW#), R290.2, R299.1
unnamed: Q37.1 (B), R368.1
unnamed: R368.2, U65.4
unnamed: U27.20 (MA0), U42.74 (MA0)
unnamed: U27.19 (MA1), U42.75 (MA1)
unnamed: U27.18 (MA2), U42.76 (MA2)
unnamed: U27.17 (MA3), U42.77 (MA3)
unnamed: U27.16 (MA4), U42.78 (MA4)
unnamed: U27.15 (MA5), U42.79 (MA5)
unnamed: U27.14 (MA6), U42.80 (MA6)
unnamed: U27.13 (MA7), U42.81 (MA7)
unnamed: U27.3 (MA8), U42.83 (MA8)
unnamed: U27.2 (MA9), U42.84 (MA9)
unnamed: U27.31 (MA10), U42.85 (MA10)
unnamed: U27.1 (MA11), U42.86 (MA11)
unnamed: U27.12 (MA12), U42.87 (MA12)
unnamed: U27.4 (MA13), U42.89 (MA13)
unnamed: U27.5 (MA14), U42.90 (MA14)
unnamed: U27.11 (MA15), U42.91 (MA15)
unnamed: U27.21 (MD0), U42.92 (MD0)
unnamed: U27.22 (MD1), U42.93 (MD1)
unnamed: U27.23 (MD2), U42.95 (MD2)
unnamed: U27.25 (MD3), U42.96 (MD3)
unnamed: U27.26 (MD4), U42.97 (MD4)
unnamed: U27.27 (MD5), U42.98 (MD5)
unnamed: U27.28 (MD6), U42.99 (MD6)
unnamed: U27.29 (MD7), U42.100 (MD7)
unnamed: U27.30 (ROMCEL0#), U42.71 (ROMCEL0)
unnamed: U27.32 (ROMOEL#), U42.72 (ROMOEL)
unnamed: R131.2, R134.1, U27.7 (ROMWEL#), U42.73 (ROMWEL)
unnamed: U41.7 (CS), U42.55 (CS)
unnamed: C141.1, U41.20 (Cext2)
unnamed: C143.1, U41.21 (Cext3)
unnamed: C142.1, C144.2, U41.22 (Cext4)
unnamed: C141.2, C145.2, U41.23 (Cext5)
unnamed: C146.1, U41.24 (Cext6)
unnamed: C142.2, U41.25 (Cext7)
unnamed: C143.2, U41.26 (Cext8)
unnamed: C146.2, U41.27 (Cext9)
unnamed: U41.4 (PD), U42.57 (PD)
unnamed: U41.5 (SCLK1), U42.53 (SCLK1)
unnamed: U41.1 (SI0), U42.59 (SI0)
unnamed: U41.2 (SI1), U42.58 (SI1)
unnamed: U41.13 (SO0), U42.62 (SO0)
unnamed: U41.17 (SO1), U42.60 (SO1)
unnamed: R362.1, R371.2, U42.12 (C_EXT)
unnamed: U42.66 (IO0), U65.1
unnamed: R296.2, R301.1, U42.42 (IORD), U56.3
unnamed: R290.1, R298.1, U42.43 (IOWR), U56.6
unnamed: R371.1, U42.11 (RC_IN)
unnamed: U56.2, U56.5, U68.3
PNET1: R161.2, R173.1, R292.1; also elsewhere on the board
PNET7: R300.1, R365.2, R373.2, R374.2, R375.2, R376.2, R377.2, R378.2, R380.2, R381.2; also elsewhere on the board
PNET12: C94.1, C133.1, C236.1, C241.2, C262.2, C263.2, C271.1, F4.1, Q37.3 (E), R134.2, R292.2, R300.2, R360.2, R361.2, R369.1, U27.8 (VCC), U42.5 (VCC), U42.15 (VCC), U42.38 (VCC), U42.56 (VCC), U42.65 (VCC), U42.88 (VCC), U56.14 (VCC), U65.5 (VCC), U68.14 (VCC)
SA0: J11.39 (SA0), U42.35 (SA0); also elsewhere on the board
SA1: J11.37 (SA1), U42.34 (SA1); also elsewhere on the board
SA2: J11.35 (SA2), U42.33 (SA2); also elsewhere on the board
SD0: J11.41 (SD0), R375.1, U42.22 (HD0); also elsewhere on the board
SD1: J11.43 (SD1), R374.1, U42.21 (HD1); also elsewhere on the board
SD2: J11.45 (SD2), R376.1, U42.19 (HD2); also elsewhere on the board
SD3: J11.3 (SD3), R373.1, U42.18 (HD3); also elsewhere on the board
SD4: J11.5 (SD4), R378.1, U42.17 (HD4); also elsewhere on the board
SD5: J11.7 (SD5), R377.1, U42.16 (HD5); also elsewhere on the board
SD6: J11.9 (SD6), R381.1, U42.14 (HD6); also elsewhere on the board
SD7: R380.1; also elsewhere on the board
SD8: J11.44 (SD8), U42.9 (HD8); also elsewhere on the board
SD9: J11.46 (SD9), U42.8 (HD9); also elsewhere on the board
SD10: J11.48 (SD10), U42.7 (HD10); also elsewhere on the board
SD11: J11.4 (SD11), U42.6 (HD11); also elsewhere on the board
SD12: J11.6 (SD12), U42.4 (HD12); also elsewhere on the board
SD13: J11.8 (SD13), U42.3 (HD13); also elsewhere on the board
SD14: J11.10 (SD14), U42.2 (HD14); also elsewhere on the board
SD15: J11.12 (SD15), U42.1 (HD15); also elsewhere on the board

Notes on the sheet:
Device_Data_BUS
Device_Address_BUS
YellowWire5
YellowWire4
Schtokey diode between YellowWire4 (Anode) and YwlloWire5 (Cathode)

Schematic: Audio.kicad_sch, PC110

Parts:
C6, C24, C50, C270: DNP; C_0402_1005Metric; not fitted
C9, C14, C23, C152, C160, C161, C162, C204, C209, C214: 10uF; C_1206_3216Metric
C10: DNP; C_1206_3216Metric; not fitted
C11, C13, C18, C21, C22, C25: 270nF; C_0603_1608Metric
C12: 250nF; C_0603_1608Metric
C15, C85, C208: 1nF; C_0402_1005Metric
C16, C154: 100pF; C_0402_1005Metric
C19, C151, C155, C157, C203, C205, C211, C212: 150nF; C_0402_1005Metric
C20: 1.5nF; C_0402_1005Metric
C44: 5.6nF; C_0402_1005Metric
C52, C53: 22pF; C_0402_1005Metric
C54: 2.7uF; C_0805_2012Metric
C57: 100nF; C_0603_1608Metric
C62: 120nF; C_0402_1005Metric
C68, C97, C149, C213, C215: 100nF; C_0402_1005Metric
C100, C150: 10nF; C_0603_1608Metric
C147, C153, C158, C248: 1uF; C_0603_1608Metric
C148, C159, C165: DNP; C_0402_1005Metric
C164: 330nF; C_0603_1608Metric
C166, C207: 300nF; C_0603_1608Metric
D3, D5: 3D
D12, D34: DNP; 3D; not fitted
D40: N; SOT-416L
J3: Audio-Jack
J7: SPKR
L2, L5, L7, L8, L13: 1.5uH; L_0603_1608Metric
Q6: ST3; SOT-416L
R23, R30, R67, R72, R75, R88, R195, R221, R370: 0; R_0402_1005Metric
R24: 4.7k; R_0402_1005Metric
R25, R29, R34: 1k; R_0402_1005Metric
R26, R32, R69, R73: 2.2k; R_0402_1005Metric
R27, R33, R77, R147, R217, R218, R224, R243, R244, R245, R247: 470k; R_0402_1005Metric
R28: 56; R_1206_3216Metric
R35, R37, R120, R121, R219, R223: 100k; R_0402_1005Metric
R36, R71, R74, R78, R220, R227, R258: 10k; R_0402_1005Metric
R47, R48, R50, R54, R55, R56, R64, R65: DNP; R_0402_1005Metric; not fitted
R70, R364: DNP; R_0402_1005Metric
R92: 47; R_0402_1005Metric
R222, R225: 6.8k; R_0402_1005Metric
R226: 120; R_1206_3216Metric
R250: 0; R_0805_2012Metric
R256: 100; R_0805_2012Metric
U4: ES488F; QFN-52
U5: 74HC14; TSSOP-14_4.4x5mm_P0.65mm
U10: YM3812; SOP-24
U11: NJM2904M; soic-8-small
U12: LM4861; SOIC-8-narrow
U17: 3E00; SOT-23-5
U18: VT74; TSSOP-14_4.4x5mm_P0.65mm
U20: 7W14; sso-8
U31: 3F01; SOT-23-5
U34: 74LV126; TSSOP-14_4.4x5mm_P0.65mm
U46: Y3014; SOP-16
U47: 3414A; SOIC-8
U48: DS1669; SOIC-8
U49: HD151015; SSOP-24_5.3x8.2mm_P0.65mm
U64: SN74LV126; TSSOP-14_4.4x5mm_P0.65mm
U66: SN74LV02; TSSOP-14_4.4x5mm_P0.65mm
U71: SN74LV32; TSSOP-14_4.4x5mm_P0.65mm
X2: 89G6821; XTAL-1

Connections:
/Audio/Enable_YMF_Bus: R147.1, U5.5, U10.3 (IC#), U31.1 (OUT), U34.1, U34.4, U34.10, U34.13
/Audio/PCMCIA_KB_sound: C25.2 (-), R35.1
/Audio/YMFDAC_OUTPUT: C11.2 (-), R26.1
Bowman_Audio_Vol_Dn: U48.7 (DnC); also elsewhere on the board
Bowman_Audio_Vol_Up: U48.2 (UpC); also elsewhere on the board
Chipset_Sound: R74.2; also elsewhere on the board
D11_2: C62.2, D12.1 (A), R88.1, U17.2 (VDD); also elsewhere on the board
ESS_AEN: U4.40 (AEN); also elsewhere on the board
ESS_CLK: R70.1; also elsewhere on the board
ESS_DACK1#: U4.36 (DACK1#); also elsewhere on the board
ESS_DRDY: U4.21 (DRDY), U66.6
ESS_IRQ1: R29.1, U4.16 (IRQ1); also elsewhere on the board
ESS_IRQ2: U4.18 (IRQ2); also elsewhere on the board
ESS_Sound: C18.1 (+), U4.9 (LineOut)
GND: C6.1, C9.2, C14.2, C16.2, C19.1, C20.1 (+), C22.2 (-), C24.1 (+), C44.1, C50.1, C52.2, C53.1, C54.2, C57.1, C62.1, C68.2, C97.2, C100.2, C148.1, C149.1, C151.2, C152.2, C153.2, C155.1, C158.1, C159.1, C160.1 (+), C161.2, C162.2 (-), C164.1, C165.2, C166.2 (-), C203.1, C204.1, C205.2, C208.1, C211.1, C212.2, C215.2, D5.1 (A), D5.3 (A), D40.1, D40.2, L2.1 (+), Q6.1 (E), R23.2, R29.2, R33.2, R73.1, R77.2, R147.2, R218.1, R219.1, R223.2, R224.2, R247.2, U4.5 (GND), U4.22 (GND), U4.26 (GND), U4.33 (GND), U10.12 (GND), U12.7 (GND), U17.3 (GND), U18.7 (GND), U31.3 (GND), U34.7 (GND), U47.4 (V-), U48.4 (RL), U48.5 (V-), U49.12 (GND), U49.13 (GND), X2.3; also elsewhere on the board
IOR#: R364.1, U66.3, U66.5; also elsewhere on the board
KB_Sound: R78.1; also elsewhere on the board
MIC_J17: R30.2; also elsewhere on the board
MIC_in_pin: C6.2, J3.4 (MI), L13.2 (-)
Modem_Audio_Out: R32.1; also elsewhere on the board
unnamed: C10.1 (+), C23.1 (+), L7.1 (+)
unnamed: C10.2 (-), C23.2 (-), C154.2 (-), R227.2, U47.1
unnamed: C11.1 (+), C50.2, R72.1, U11.7
unnamed: C12.1 (+), U4.1 (FoutR)
unnamed: C12.2 (-), C24.2 (-), U4.2 (CinR)
unnamed: C13.1 (+), U48.6 (RW)
unnamed: C13.2 (-), R217.2, R218.2, U47.3 (+)
unnamed: C15.2 (-), R25.2, R26.2, R32.2, R34.2, R35.2, U47.6 (-)
unnamed: C18.2 (-), R34.1
unnamed: C20.2 (-), C21.2 (-), U4.8 (CinL)
unnamed: C21.1 (+), U4.7 (FoutL)
unnamed: C22.1 (+), U4.10 (ByPass)
unnamed: C25.1 (+), Q6.3 (C), R36.2
unnamed: C85.1 (+), R24.1, R121.1, U12.4 (IN-)
unnamed: C85.2 (-), J7.2, R121.2, U12.5 (OUT+)
unnamed: C147.1 (+), U48.1 (RH)
unnamed: C15.1 (+), C147.2 (-), R25.1, U47.7
unnamed: C150.1 (+), U4.4 (MIC)
unnamed: C150.2 (-), R221.1, R225.1
unnamed: C153.1, R37.2, R217.1
unnamed: C154.1 (+), R220.1, R227.1, U47.2 (-)
unnamed: C160.2 (-), C166.1 (+), R224.1, U4.11 (ByPass)
unnamed: C162.1 (+), R222.2, R225.2
unnamed: C164.2, R220.2
unnamed: C207.1 (+), R71.2
unnamed: C213.2, C214.2, R250.1
unnamed: C270.1, U64.11
unnamed: D3.2 (K), U5.6
unnamed: D5.2 (K), Q6.2 (B), R71.1, R74.1, R78.2
unnamed: J3.3 (G), L2.2 (-)
unnamed: C148.2, J3.5 (MO), L8.2 (-)
unnamed: C165.1, J3.2 (SI), L7.2 (-)
unnamed: C159.2, J3.1 (SO), L5.1 (+)
unnamed: J7.1, U12.8 (OUT-)
unnamed: C16.1, L5.2 (-), R24.2
unnamed: L8.1 (+), R30.1
unnamed: L13.1 (+), R221.2
unnamed: R67.1, R73.2, U11.1
unnamed: R370.2, U66.10
unnamed: C152.1, C155.2, C161.1, R226.1, U4.6 (CMR)
unnamed: U4.37 (IOR), U71.11
unnamed: U4.38 (IOW), U71.8
unnamed: R23.1, U4.52 (REF)
unnamed: U4.39 (RESET), U20.5
unnamed: C213.1, U4.44 (VCC_Bus), U49.24 (VCCB)
unnamed: C52.1, R70.2, U4.34 (Xin), X2.1
unnamed: C53.2, U4.35 (Xout), X2.2
unnamed: R77.1, U10.4 (AO), U34.11
unnamed: R244.2, U10.7 (CS#), U34.3
unnamed: R64.2, U4.23 (D0), U10.10 (D0), U49.22 (B0)
unnamed: R54.2, U4.24 (D1), U10.11 (D1), U49.21 (B1)
unnamed: R47.2, U4.25 (D2), U10.13 (D2), U49.20 (B2)
unnamed: R50.2, U4.28 (D3), U10.14 (D3), U49.19 (B3)
unnamed: R65.2, U4.29 (D4), U10.15 (D4), U49.18 (B4)
unnamed: R55.1, U4.30 (D5), U10.16 (D5), U49.17 (B5)
unnamed: R48.1, U4.31 (D6), U10.17 (D6), U49.16 (B6)
unnamed: R56.1, U4.32 (D7), U10.18 (D7), U49.15 (B7)
unnamed: R92.2, U10.24 (M)
unnamed: U10.21 (MO), U46.7 (SD)
unnamed: R243.2, U10.6 (RD#), U34.6
unnamed: U10.20 (SH), U46.4 (LOAD)
unnamed: U10.23 (SY), U46.10 (Clock)
unnamed: R245.2, U10.5 (WR#), U34.8
unnamed: C214.1, R75.1, U11.3 (+)
unnamed: R67.2, U11.2 (-), U46.16 (MP)
unnamed: C44.2, R69.2, U11.5 (+)
unnamed: R72.2, U11.6 (-)
unnamed: C157.1, C209.1, R256.1, U11.8 (V+), U46.1 (VDD)
unnamed: C157.2, C209.2, R250.2, U11.4 (V-), U46.12 (GND)
unnamed: C54.1, U12.2 (Bypass), U12.3 (IN+)
unnamed: C248.2, D40.3, R247.1, U12.1 (~SD)
unnamed: C57.2, D12.3 (A), U17.5 (CD)
unnamed: U17.1 (OUT), U20.3
unnamed: U18.2 (D), U18.6 (~Q), U18.11 (C)
unnamed: R92.1, U18.8 (~Q), U18.12 (D)
unnamed: C100.1, D34.3 (A), U31.5 (CD)
unnamed: C97.1, D34.1 (A), R195.2, U31.2 (VDD)
unnamed: R75.2, U46.14 (RB)
unnamed: R69.1, U46.2 (toBUFF)
unnamed: C158.2, R27.1, R33.1, U47.5 (+)
unnamed: R219.2, U49.11 (A8)
unnamed: R223.1, U49.14 (B8)
unnamed: R364.2, R370.1, U49.2 (DIR)
unnamed: C270.2, D3.1 (A), D3.3 (A), R258.2, U49.23 (G#)
unnamed: U66.1, U66.8
unnamed: U66.4, U66.9
PCMCIA_Sound: C207.2 (-), R120.2; also elsewhere on the board
PNET1: C208.2, C211.2, C212.1, C215.1, R120.1, R258.1, U49.1 (VCCA), U64.13; also elsewhere on the board
PNET2: C68.1, C203.2, C204.2, C205.1, D34.2 (K), R28.2, R195.1, R243.1, R244.1, R245.1, R256.2, U10.1 (VCC), U12.6 (VDD), U18.1 (~R), U18.4 (~S), U18.10 (~S), U18.13 (~R), U18.14 (VCC); also elsewhere on the board
PNET5: C19.2, D12.2 (K), R47.1, R48.2, R50.1, R54.1, R55.2, R56.2, R64.1, R65.1, R88.2, R226.2, U4.20 (VCC), U4.27 (VCC), U34.14 (VCC); also elsewhere on the board
PNET6: C9.1, C14.1, C149.2, C151.1, R27.2, R28.1, R36.1, R37.1, R222.1, U47.8 (V+), U48.8 (V+)
PWRGD_shift: C248.1; also elsewhere on the board
PWRGD_shift_buff: U71.10, U71.13; also elsewhere on the board
SA1: U4.42 (A1); also elsewhere on the board
SA2: U4.43 (A2); also elsewhere on the board
SA3: U4.45 (A3); also elsewhere on the board
SA4: U4.46 (A4); also elsewhere on the board
SA5: U4.47 (A5); also elsewhere on the board
SA6: U4.48 (A6); also elsewhere on the board
SA7: U4.49 (A7); also elsewhere on the board
SA8: U4.50 (A8); also elsewhere on the board
SA9: U4.51 (A9); also elsewhere on the board
SD0: U49.3 (A0); also elsewhere on the board
SD1: U49.4 (A1); also elsewhere on the board
SD2: U49.5 (A2); also elsewhere on the board
SD3: U49.6 (A3); also elsewhere on the board
SD4: U49.7 (A4); also elsewhere on the board
SD5: U49.8 (A5); also elsewhere on the board
SD6: U49.9 (A6); also elsewhere on the board
SD7: U49.10 (A7); also elsewhere on the board
YMF_CLK: U18.3 (C); also elsewhere on the board
YMF_CS#_Buf: U4.14 (DIR), U34.2, U64.12, U66.2
YMF_RD#_Buf: U34.5, U71.12; also elsewhere on the board
YMF_SA0_A0: U4.41 (A0), U34.12; also elsewhere on the board
YMF_WR#_Buf: U34.9, U71.9; also elsewhere on the board

Notes on the sheet:
Device_Data_BUS
Device_Address_BUS

Schematic: ROM.kicad_sch

Parts:
C246: 150nF; C_0603_1608Metric
C249, C282: 150nF; C_0402_1005Metric
D19: N; SOT-416L
D20: 3D; SOT-416L
Q35: 8C; SOT-523
Q36: 7C; TSOT-23
R112: 47k; R_0402_1005Metric
R113, R327: 470k; R_0402_1005Metric
R320: 10k; R_0402_1005Metric
R321: 100k; R_0402_1005Metric
U24: E4; SOT-353
U36: MSM538032E; SOP48
U59: 28F002BX; Flash-40
U60: E3; SOT-353

Connections:
BIOS_SA17: U59.40 (A17); also elsewhere on the board
Bowman5_Buff: U60.1; also elsewhere on the board
Chipset_BIOS_CE#: U59.22 (CE#); also elsewhere on the board
Chipset_SA16: U59.1 (A16); also elsewhere on the board
D28_1: Q36.2 (E); also elsewhere on the board
GND: C246.2 (-), C249.1 (+), C282.2 (-), Q35.2 (E), R113.1, R327.2, U24.3 (GND), U36.15 (VSS), U59.23 (GND), U59.39 (GND), U60.3 (GND); also elsewhere on the board
MEMR#: U36.16 (OE#), U59.24 (OE#); also elsewhere on the board
MEMW#: U24.1; also elsewhere on the board
unnamed: C246.1 (+), D20.1, Q36.3 (C), R327.1, U59.11 (VPP)
unnamed: D19.1, D19.2, R112.2, U24.2
unnamed: Q35.1 (B), R321.2
unnamed: Q35.3 (C), R320.1
unnamed: Q36.1 (B), R320.2
unnamed: R321.1, U60.4
unnamed: D20.3, R113.2, U59.10 (RP#)
unnamed: U24.4, U59.9 (WE#)
OKI_CE#: U36.14 (CE#); also elsewhere on the board
OKI_SA12: U36.40 (A12); also elsewhere on the board
OKI_SA13: U36.39 (A13); also elsewhere on the board
OKI_SA14: U36.38 (A14); also elsewhere on the board
OKI_SA15: U36.37 (A15); also elsewhere on the board
OKI_SA16: U36.36 (A16); also elsewhere on the board
OKI_SA17: U36.5 (A17); also elsewhere on the board
OKI_SA18: U36.4 (A18); also elsewhere on the board
OKI_SA19: U36.45 (A19); also elsewhere on the board
PNET5: U60.5 (VCC); also elsewhere on the board
PNET7: C249.2 (-), C282.1 (+), R112.1, U24.5 (VCC), U36.25 (VCC), U36.35 (BHE), U59.30 (VCC), U59.31 (VCC); also elsewhere on the board
PWRGD: D20.2; also elsewhere on the board
PWRGD_shift_buff: U60.2; also elsewhere on the board
Pluto_BIOS_WR_EN: D19.3; also elsewhere on the board
SA0: U59.21 (A0); also elsewhere on the board
SA1: U36.13 (A0), U59.20 (A1); also elsewhere on the board
SA2: U36.12 (A1), U59.19 (A2); also elsewhere on the board
SA3: U36.11 (A2), U59.18 (A3); also elsewhere on the board
SA4: U36.10 (A3), U59.17 (A4); also elsewhere on the board
SA5: U36.9 (A4), U59.16 (A5); also elsewhere on the board
SA6: U36.8 (A5), U59.15 (A6); also elsewhere on the board
SA7: U36.7 (A6), U59.14 (A7); also elsewhere on the board
SA8: U36.6 (A7), U59.8 (A8); also elsewhere on the board
SA9: U36.44 (A8), U59.7 (A9); also elsewhere on the board
SA10: U36.43 (A9), U59.36 (A10); also elsewhere on the board
SA11: U36.42 (A10), U59.6 (A11); also elsewhere on the board
SA12: U36.41 (A11), U59.5 (A12); also elsewhere on the board
SA13: U59.4 (A13); also elsewhere on the board
SA14: U59.3 (A14); also elsewhere on the board
SA15: U59.2 (A15); also elsewhere on the board
SD0: U36.17 (D0), U59.25 (DQ0); also elsewhere on the board
SD1: U36.19 (D1), U59.26 (DQ1); also elsewhere on the board
SD2: U36.21 (D2), U59.27 (DQ2); also elsewhere on the board
SD3: U36.23 (D3), U59.28 (DQ3); also elsewhere on the board
SD4: U36.26 (D4), U59.32 (DQ4); also elsewhere on the board
SD5: U36.28 (D5), U59.33 (DQ5); also elsewhere on the board
SD6: U36.30 (D6), U59.34 (DQ6); also elsewhere on the board
SD7: U36.32 (D7), U59.35 (DQ7); also elsewhere on the board
SD8: U36.18 (D8); also elsewhere on the board
SD9: U36.20 (D9); also elsewhere on the board
SD10: U36.22 (D10); also elsewhere on the board
SD11: U36.24 (D11); also elsewhere on the board
SD12: U36.27 (D12); also elsewhere on the board
SD13: U36.29 (D13); also elsewhere on the board
SD14: U36.31 (D14); also elsewhere on the board
SD15: U36.33 (D15); also elsewhere on the board

Notes on the sheet:
Device_Data_BUS
Device_Address_BUS
OKI_Extra_Address
